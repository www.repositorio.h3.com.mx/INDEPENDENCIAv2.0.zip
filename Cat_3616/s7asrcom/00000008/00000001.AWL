DATA_BLOCK "IMAC_VALVE_RECORD"
TITLE = VALVE_RECORD
AUTHOR : HottendU
FAMILY : IMAC
VERSION : 0.2


  STRUCT
   VALVE_No001 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 001
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL  := TRUE;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL  := TRUE;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME  := T#5S;	// Setpoint Action Fault delay
     DlyTOpening : TIME  := T#1S;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME  := T#1S;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME  := T#5S;	// Setpoint feedback fault delay
     DlyTReverse : TIME  := T#2S;	// Setpoint change direction
     DlyTOvertravel : TIME  := T#1S;	// Setpoint auto alarm delay
     DlyTExtFault : TIME  := T#2S;	// Setpoint external fault delay
     DlyTRestart : TIME  := T#20S;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No002 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 002
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL  := TRUE;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL  := TRUE;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME  := T#5S;	// Setpoint Action Fault delay
     DlyTOpening : TIME  := T#1S;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME  := T#1S;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME  := T#5S;	// Setpoint feedback fault delay
     DlyTReverse : TIME  := T#2S;	// Setpoint change direction
     DlyTOvertravel : TIME  := T#1S;	// Setpoint auto alarm delay
     DlyTExtFault : TIME  := T#2S;	// Setpoint external fault delay
     DlyTRestart : TIME  := T#20S;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No003 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 003
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL  := TRUE;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL  := TRUE;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME  := T#5S;	// Setpoint Action Fault delay
     DlyTOpening : TIME  := T#1S;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME  := T#1S;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME  := T#5S;	// Setpoint feedback fault delay
     DlyTReverse : TIME  := T#2S;	// Setpoint change direction
     DlyTOvertravel : TIME  := T#1S;	// Setpoint auto alarm delay
     DlyTExtFault : TIME  := T#2S;	// Setpoint external fault delay
     DlyTRestart : TIME  := T#20S;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No004 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 004
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No005 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 005
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No006 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 006
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No007 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 007
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No008 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 008
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No009 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 009
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No010 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 010
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No011 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 011
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No012 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 012
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No013 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 013
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No014 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 014
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No015 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 015
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No016 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 016
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No017 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 017
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No018 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 018
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No019 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 019
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No020 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 020
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No021 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 021
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No022 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 022
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No023 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 023
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No024 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 024
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No025 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 025
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No026 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 026
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No027 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 027
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No028 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 028
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No029 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 029
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No030 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 030
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No031 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 031
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No032 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 032
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No033 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 033
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No034 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 034
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No035 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 035
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No036 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 036
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No037 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 037
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No038 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 038
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No039 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 039
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No040 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 040
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No041 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 041
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No042 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 042
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No043 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 043
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No044 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 044
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No045 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 045
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No046 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 046
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No047 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 047
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No048 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 048
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No049 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 049
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No050 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 050
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No051 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 051
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No052 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 052
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No053 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 053
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No054 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 054
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No0055 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 055
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No056 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 056
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No057 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 057
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No058 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 058
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No059 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 059
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No060 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 060
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No061 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 061
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No062 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 062
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No063 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 063
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No064 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 064
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No065 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 065
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No066 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 066
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No067 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 067
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No068 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 068
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No069 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 069
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No070 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 070
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No071 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 071
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No072 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 072
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No073 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 073
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No074 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 074
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No075 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 075
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No076 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 076
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No077 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 077
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No078 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 078
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No079 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 079
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No080 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 080
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No081 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 081
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No082 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 082
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No083 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 083
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No084 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 084
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No085 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 085
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No086 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 086
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No087 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 087
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No0088 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 088
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No089 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 089
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No090 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 090
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No091 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 091
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No092 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 092
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No093 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 093
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No094 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 094
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No095 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 095
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No096 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 096
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No097 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 097
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No098 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 098
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No099 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 099
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
   VALVE_No0100 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    Status3 : BYTE ;
    InputEdges : BYTE ;
    AutoEdges : WORD ;
    DataTimeActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOpening : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeClosing : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeReverse : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeOvertravel : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF VALVE - Instance 100
     Modeswitches : STRUCT
      M0_SingleActingValve : BOOL ;	// Single acting valve (1); Double acting valve (0)
      M1_ResetMode : BOOL ;	// Open/Close and RESET (1); only RESET (0)
      M2_OperationMode : BOOL ;	// AUTO/MANUAL/LOCAL(1); Only MANUAL/LOCAL
      M3_Status : BOOL ;	// Change status OPENED/CLOSED by switching from REMOTE to LOCAL (1)
      M4_LockInput : BOOL ;	// Commands and failure (1); only failure
      M5_ESO : BOOL ;	// Open valve if ESO=1 (1); Close valve if ESO=1 (0)
      M6_ReverseTime : BOOL ;	// Double acting valves: Reverse Time ON
      M7_OvertravelTime : BOOL ;	// Double acting valves: Overtravel Time ON
      M8_Spare : BOOL ;	// Spare
      M9_OpenAfterBlackout : BOOL ;	// Open after blackout (1)
      M10_ExtFaultNC : BOOL ;	// External Fault is NC (1); NO (0)
      M11_Spare : BOOL ;	// Spare
      M12_Spare : BOOL ;	// Spare
      M13_LocalAutoMode : BOOL ;	// Set automatic status if RMOT-input is in local
      M14_Spare : BOOL ;	// Spare
      M15_Test : BOOL ;	// Testbit (1)
     END_STRUCT ;
     DlyTActFault : TIME ;	// Setpoint Action Fault delay
     DlyTOpening : TIME ;	// Setpoint Waiting Delay Slow->Fast
     DlyTClosing : TIME ;	// Setpoint Waiting Delay Fast->Slow
     DlyTFeedback : TIME ;	// Setpoint feedback fault delay
     DlyTReverse : TIME ;	// Setpoint change direction
     DlyTOvertravel : TIME ;	// Setpoint auto alarm delay
     DlyTExtFault : TIME ;	// Setpoint external fault delay
     DlyTRestart : TIME ;	// Setpoint restart after blackout delay
    END_STRUCT ;
   END_STRUCT ;
  END_STRUCT ;
BEGIN
   VALVE_No001.System := W#16#0;
   VALVE_No001.CmdOS := W#16#0;
   VALVE_No001.MirrorCmdOS := W#16#0;
   VALVE_No001.Test := W#16#0;
   VALVE_No001.AlarmOS := W#16#0;
   VALVE_No001.StatusOS := W#16#0;
   VALVE_No001.SysStatusOS := W#16#0;
   VALVE_No001.Status1 := W#16#0;
   VALVE_No001.Status2 := W#16#0;
   VALVE_No001.Status3 := B#16#0;
   VALVE_No001.InputEdges := B#16#0;
   VALVE_No001.AutoEdges := W#16#0;
   VALVE_No001.DataTimeActFault.StartTime := L#0;
   VALVE_No001.DataTimeActFault.StartEdge := FALSE;
   VALVE_No001.DataTimeOpening.StartTime := L#0;
   VALVE_No001.DataTimeOpening.StartEdge := FALSE;
   VALVE_No001.DataTimeClosing.StartTime := L#0;
   VALVE_No001.DataTimeClosing.StartEdge := FALSE;
   VALVE_No001.DataTimeFeedback.StartTime := L#0;
   VALVE_No001.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No001.DataTimeReverse.StartTime := L#0;
   VALVE_No001.DataTimeReverse.StartEdge := FALSE;
   VALVE_No001.DataTimeOvertravel.StartTime := L#0;
   VALVE_No001.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No001.DataTimeExtFault.StartTime := L#0;
   VALVE_No001.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No001.DataTimeRestart.StartTime := L#0;
   VALVE_No001.DataTimeRestart.StartEdge := FALSE;
   VALVE_No001.PCONF.Modeswitches.M0_SingleActingValve := TRUE;
   VALVE_No001.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No001.PCONF.Modeswitches.M2_OperationMode := TRUE;
   VALVE_No001.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No001.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No001.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No001.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No001.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No001.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No001.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No001.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No001.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No001.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No001.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No001.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No001.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No001.PCONF.DlyTActFault := T#5S;
   VALVE_No001.PCONF.DlyTOpening := T#1S;
   VALVE_No001.PCONF.DlyTClosing := T#1S;
   VALVE_No001.PCONF.DlyTFeedback := T#5S;
   VALVE_No001.PCONF.DlyTReverse := T#2S;
   VALVE_No001.PCONF.DlyTOvertravel := T#1S;
   VALVE_No001.PCONF.DlyTExtFault := T#2S;
   VALVE_No001.PCONF.DlyTRestart := T#20S;
   VALVE_No002.System := W#16#0;
   VALVE_No002.CmdOS := W#16#0;
   VALVE_No002.MirrorCmdOS := W#16#0;
   VALVE_No002.Test := W#16#0;
   VALVE_No002.AlarmOS := W#16#0;
   VALVE_No002.StatusOS := W#16#0;
   VALVE_No002.SysStatusOS := W#16#0;
   VALVE_No002.Status1 := W#16#0;
   VALVE_No002.Status2 := W#16#0;
   VALVE_No002.Status3 := B#16#0;
   VALVE_No002.InputEdges := B#16#0;
   VALVE_No002.AutoEdges := W#16#0;
   VALVE_No002.DataTimeActFault.StartTime := L#0;
   VALVE_No002.DataTimeActFault.StartEdge := FALSE;
   VALVE_No002.DataTimeOpening.StartTime := L#0;
   VALVE_No002.DataTimeOpening.StartEdge := FALSE;
   VALVE_No002.DataTimeClosing.StartTime := L#0;
   VALVE_No002.DataTimeClosing.StartEdge := FALSE;
   VALVE_No002.DataTimeFeedback.StartTime := L#0;
   VALVE_No002.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No002.DataTimeReverse.StartTime := L#0;
   VALVE_No002.DataTimeReverse.StartEdge := FALSE;
   VALVE_No002.DataTimeOvertravel.StartTime := L#0;
   VALVE_No002.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No002.DataTimeExtFault.StartTime := L#0;
   VALVE_No002.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No002.DataTimeRestart.StartTime := L#0;
   VALVE_No002.DataTimeRestart.StartEdge := FALSE;
   VALVE_No002.PCONF.Modeswitches.M0_SingleActingValve := TRUE;
   VALVE_No002.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No002.PCONF.Modeswitches.M2_OperationMode := TRUE;
   VALVE_No002.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No002.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No002.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No002.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No002.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No002.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No002.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No002.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No002.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No002.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No002.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No002.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No002.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No002.PCONF.DlyTActFault := T#5S;
   VALVE_No002.PCONF.DlyTOpening := T#1S;
   VALVE_No002.PCONF.DlyTClosing := T#1S;
   VALVE_No002.PCONF.DlyTFeedback := T#5S;
   VALVE_No002.PCONF.DlyTReverse := T#2S;
   VALVE_No002.PCONF.DlyTOvertravel := T#1S;
   VALVE_No002.PCONF.DlyTExtFault := T#2S;
   VALVE_No002.PCONF.DlyTRestart := T#20S;
   VALVE_No003.System := W#16#0;
   VALVE_No003.CmdOS := W#16#0;
   VALVE_No003.MirrorCmdOS := W#16#0;
   VALVE_No003.Test := W#16#0;
   VALVE_No003.AlarmOS := W#16#0;
   VALVE_No003.StatusOS := W#16#0;
   VALVE_No003.SysStatusOS := W#16#0;
   VALVE_No003.Status1 := W#16#0;
   VALVE_No003.Status2 := W#16#0;
   VALVE_No003.Status3 := B#16#0;
   VALVE_No003.InputEdges := B#16#0;
   VALVE_No003.AutoEdges := W#16#0;
   VALVE_No003.DataTimeActFault.StartTime := L#0;
   VALVE_No003.DataTimeActFault.StartEdge := FALSE;
   VALVE_No003.DataTimeOpening.StartTime := L#0;
   VALVE_No003.DataTimeOpening.StartEdge := FALSE;
   VALVE_No003.DataTimeClosing.StartTime := L#0;
   VALVE_No003.DataTimeClosing.StartEdge := FALSE;
   VALVE_No003.DataTimeFeedback.StartTime := L#0;
   VALVE_No003.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No003.DataTimeReverse.StartTime := L#0;
   VALVE_No003.DataTimeReverse.StartEdge := FALSE;
   VALVE_No003.DataTimeOvertravel.StartTime := L#0;
   VALVE_No003.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No003.DataTimeExtFault.StartTime := L#0;
   VALVE_No003.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No003.DataTimeRestart.StartTime := L#0;
   VALVE_No003.DataTimeRestart.StartEdge := FALSE;
   VALVE_No003.PCONF.Modeswitches.M0_SingleActingValve := TRUE;
   VALVE_No003.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No003.PCONF.Modeswitches.M2_OperationMode := TRUE;
   VALVE_No003.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No003.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No003.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No003.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No003.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No003.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No003.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No003.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No003.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No003.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No003.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No003.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No003.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No003.PCONF.DlyTActFault := T#5S;
   VALVE_No003.PCONF.DlyTOpening := T#1S;
   VALVE_No003.PCONF.DlyTClosing := T#1S;
   VALVE_No003.PCONF.DlyTFeedback := T#5S;
   VALVE_No003.PCONF.DlyTReverse := T#2S;
   VALVE_No003.PCONF.DlyTOvertravel := T#1S;
   VALVE_No003.PCONF.DlyTExtFault := T#2S;
   VALVE_No003.PCONF.DlyTRestart := T#20S;
   VALVE_No004.System := W#16#0;
   VALVE_No004.CmdOS := W#16#0;
   VALVE_No004.MirrorCmdOS := W#16#0;
   VALVE_No004.Test := W#16#0;
   VALVE_No004.AlarmOS := W#16#0;
   VALVE_No004.StatusOS := W#16#0;
   VALVE_No004.SysStatusOS := W#16#0;
   VALVE_No004.Status1 := W#16#0;
   VALVE_No004.Status2 := W#16#0;
   VALVE_No004.Status3 := B#16#0;
   VALVE_No004.InputEdges := B#16#0;
   VALVE_No004.AutoEdges := W#16#0;
   VALVE_No004.DataTimeActFault.StartTime := L#0;
   VALVE_No004.DataTimeActFault.StartEdge := FALSE;
   VALVE_No004.DataTimeOpening.StartTime := L#0;
   VALVE_No004.DataTimeOpening.StartEdge := FALSE;
   VALVE_No004.DataTimeClosing.StartTime := L#0;
   VALVE_No004.DataTimeClosing.StartEdge := FALSE;
   VALVE_No004.DataTimeFeedback.StartTime := L#0;
   VALVE_No004.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No004.DataTimeReverse.StartTime := L#0;
   VALVE_No004.DataTimeReverse.StartEdge := FALSE;
   VALVE_No004.DataTimeOvertravel.StartTime := L#0;
   VALVE_No004.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No004.DataTimeExtFault.StartTime := L#0;
   VALVE_No004.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No004.DataTimeRestart.StartTime := L#0;
   VALVE_No004.DataTimeRestart.StartEdge := FALSE;
   VALVE_No004.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No004.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No004.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No004.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No004.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No004.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No004.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No004.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No004.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No004.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No004.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No004.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No004.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No004.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No004.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No004.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No004.PCONF.DlyTActFault := T#0MS;
   VALVE_No004.PCONF.DlyTOpening := T#0MS;
   VALVE_No004.PCONF.DlyTClosing := T#0MS;
   VALVE_No004.PCONF.DlyTFeedback := T#0MS;
   VALVE_No004.PCONF.DlyTReverse := T#0MS;
   VALVE_No004.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No004.PCONF.DlyTExtFault := T#0MS;
   VALVE_No004.PCONF.DlyTRestart := T#0MS;
   VALVE_No005.System := W#16#0;
   VALVE_No005.CmdOS := W#16#0;
   VALVE_No005.MirrorCmdOS := W#16#0;
   VALVE_No005.Test := W#16#0;
   VALVE_No005.AlarmOS := W#16#0;
   VALVE_No005.StatusOS := W#16#0;
   VALVE_No005.SysStatusOS := W#16#0;
   VALVE_No005.Status1 := W#16#0;
   VALVE_No005.Status2 := W#16#0;
   VALVE_No005.Status3 := B#16#0;
   VALVE_No005.InputEdges := B#16#0;
   VALVE_No005.AutoEdges := W#16#0;
   VALVE_No005.DataTimeActFault.StartTime := L#0;
   VALVE_No005.DataTimeActFault.StartEdge := FALSE;
   VALVE_No005.DataTimeOpening.StartTime := L#0;
   VALVE_No005.DataTimeOpening.StartEdge := FALSE;
   VALVE_No005.DataTimeClosing.StartTime := L#0;
   VALVE_No005.DataTimeClosing.StartEdge := FALSE;
   VALVE_No005.DataTimeFeedback.StartTime := L#0;
   VALVE_No005.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No005.DataTimeReverse.StartTime := L#0;
   VALVE_No005.DataTimeReverse.StartEdge := FALSE;
   VALVE_No005.DataTimeOvertravel.StartTime := L#0;
   VALVE_No005.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No005.DataTimeExtFault.StartTime := L#0;
   VALVE_No005.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No005.DataTimeRestart.StartTime := L#0;
   VALVE_No005.DataTimeRestart.StartEdge := FALSE;
   VALVE_No005.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No005.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No005.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No005.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No005.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No005.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No005.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No005.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No005.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No005.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No005.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No005.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No005.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No005.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No005.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No005.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No005.PCONF.DlyTActFault := T#0MS;
   VALVE_No005.PCONF.DlyTOpening := T#0MS;
   VALVE_No005.PCONF.DlyTClosing := T#0MS;
   VALVE_No005.PCONF.DlyTFeedback := T#0MS;
   VALVE_No005.PCONF.DlyTReverse := T#0MS;
   VALVE_No005.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No005.PCONF.DlyTExtFault := T#0MS;
   VALVE_No005.PCONF.DlyTRestart := T#0MS;
   VALVE_No006.System := W#16#0;
   VALVE_No006.CmdOS := W#16#0;
   VALVE_No006.MirrorCmdOS := W#16#0;
   VALVE_No006.Test := W#16#0;
   VALVE_No006.AlarmOS := W#16#0;
   VALVE_No006.StatusOS := W#16#0;
   VALVE_No006.SysStatusOS := W#16#0;
   VALVE_No006.Status1 := W#16#0;
   VALVE_No006.Status2 := W#16#0;
   VALVE_No006.Status3 := B#16#0;
   VALVE_No006.InputEdges := B#16#0;
   VALVE_No006.AutoEdges := W#16#0;
   VALVE_No006.DataTimeActFault.StartTime := L#0;
   VALVE_No006.DataTimeActFault.StartEdge := FALSE;
   VALVE_No006.DataTimeOpening.StartTime := L#0;
   VALVE_No006.DataTimeOpening.StartEdge := FALSE;
   VALVE_No006.DataTimeClosing.StartTime := L#0;
   VALVE_No006.DataTimeClosing.StartEdge := FALSE;
   VALVE_No006.DataTimeFeedback.StartTime := L#0;
   VALVE_No006.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No006.DataTimeReverse.StartTime := L#0;
   VALVE_No006.DataTimeReverse.StartEdge := FALSE;
   VALVE_No006.DataTimeOvertravel.StartTime := L#0;
   VALVE_No006.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No006.DataTimeExtFault.StartTime := L#0;
   VALVE_No006.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No006.DataTimeRestart.StartTime := L#0;
   VALVE_No006.DataTimeRestart.StartEdge := FALSE;
   VALVE_No006.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No006.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No006.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No006.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No006.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No006.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No006.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No006.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No006.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No006.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No006.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No006.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No006.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No006.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No006.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No006.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No006.PCONF.DlyTActFault := T#0MS;
   VALVE_No006.PCONF.DlyTOpening := T#0MS;
   VALVE_No006.PCONF.DlyTClosing := T#0MS;
   VALVE_No006.PCONF.DlyTFeedback := T#0MS;
   VALVE_No006.PCONF.DlyTReverse := T#0MS;
   VALVE_No006.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No006.PCONF.DlyTExtFault := T#0MS;
   VALVE_No006.PCONF.DlyTRestart := T#0MS;
   VALVE_No007.System := W#16#0;
   VALVE_No007.CmdOS := W#16#0;
   VALVE_No007.MirrorCmdOS := W#16#0;
   VALVE_No007.Test := W#16#0;
   VALVE_No007.AlarmOS := W#16#0;
   VALVE_No007.StatusOS := W#16#0;
   VALVE_No007.SysStatusOS := W#16#0;
   VALVE_No007.Status1 := W#16#0;
   VALVE_No007.Status2 := W#16#0;
   VALVE_No007.Status3 := B#16#0;
   VALVE_No007.InputEdges := B#16#0;
   VALVE_No007.AutoEdges := W#16#0;
   VALVE_No007.DataTimeActFault.StartTime := L#0;
   VALVE_No007.DataTimeActFault.StartEdge := FALSE;
   VALVE_No007.DataTimeOpening.StartTime := L#0;
   VALVE_No007.DataTimeOpening.StartEdge := FALSE;
   VALVE_No007.DataTimeClosing.StartTime := L#0;
   VALVE_No007.DataTimeClosing.StartEdge := FALSE;
   VALVE_No007.DataTimeFeedback.StartTime := L#0;
   VALVE_No007.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No007.DataTimeReverse.StartTime := L#0;
   VALVE_No007.DataTimeReverse.StartEdge := FALSE;
   VALVE_No007.DataTimeOvertravel.StartTime := L#0;
   VALVE_No007.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No007.DataTimeExtFault.StartTime := L#0;
   VALVE_No007.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No007.DataTimeRestart.StartTime := L#0;
   VALVE_No007.DataTimeRestart.StartEdge := FALSE;
   VALVE_No007.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No007.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No007.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No007.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No007.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No007.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No007.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No007.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No007.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No007.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No007.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No007.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No007.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No007.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No007.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No007.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No007.PCONF.DlyTActFault := T#0MS;
   VALVE_No007.PCONF.DlyTOpening := T#0MS;
   VALVE_No007.PCONF.DlyTClosing := T#0MS;
   VALVE_No007.PCONF.DlyTFeedback := T#0MS;
   VALVE_No007.PCONF.DlyTReverse := T#0MS;
   VALVE_No007.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No007.PCONF.DlyTExtFault := T#0MS;
   VALVE_No007.PCONF.DlyTRestart := T#0MS;
   VALVE_No008.System := W#16#0;
   VALVE_No008.CmdOS := W#16#0;
   VALVE_No008.MirrorCmdOS := W#16#0;
   VALVE_No008.Test := W#16#0;
   VALVE_No008.AlarmOS := W#16#0;
   VALVE_No008.StatusOS := W#16#0;
   VALVE_No008.SysStatusOS := W#16#0;
   VALVE_No008.Status1 := W#16#0;
   VALVE_No008.Status2 := W#16#0;
   VALVE_No008.Status3 := B#16#0;
   VALVE_No008.InputEdges := B#16#0;
   VALVE_No008.AutoEdges := W#16#0;
   VALVE_No008.DataTimeActFault.StartTime := L#0;
   VALVE_No008.DataTimeActFault.StartEdge := FALSE;
   VALVE_No008.DataTimeOpening.StartTime := L#0;
   VALVE_No008.DataTimeOpening.StartEdge := FALSE;
   VALVE_No008.DataTimeClosing.StartTime := L#0;
   VALVE_No008.DataTimeClosing.StartEdge := FALSE;
   VALVE_No008.DataTimeFeedback.StartTime := L#0;
   VALVE_No008.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No008.DataTimeReverse.StartTime := L#0;
   VALVE_No008.DataTimeReverse.StartEdge := FALSE;
   VALVE_No008.DataTimeOvertravel.StartTime := L#0;
   VALVE_No008.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No008.DataTimeExtFault.StartTime := L#0;
   VALVE_No008.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No008.DataTimeRestart.StartTime := L#0;
   VALVE_No008.DataTimeRestart.StartEdge := FALSE;
   VALVE_No008.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No008.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No008.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No008.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No008.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No008.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No008.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No008.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No008.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No008.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No008.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No008.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No008.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No008.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No008.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No008.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No008.PCONF.DlyTActFault := T#0MS;
   VALVE_No008.PCONF.DlyTOpening := T#0MS;
   VALVE_No008.PCONF.DlyTClosing := T#0MS;
   VALVE_No008.PCONF.DlyTFeedback := T#0MS;
   VALVE_No008.PCONF.DlyTReverse := T#0MS;
   VALVE_No008.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No008.PCONF.DlyTExtFault := T#0MS;
   VALVE_No008.PCONF.DlyTRestart := T#0MS;
   VALVE_No009.System := W#16#0;
   VALVE_No009.CmdOS := W#16#0;
   VALVE_No009.MirrorCmdOS := W#16#0;
   VALVE_No009.Test := W#16#0;
   VALVE_No009.AlarmOS := W#16#0;
   VALVE_No009.StatusOS := W#16#0;
   VALVE_No009.SysStatusOS := W#16#0;
   VALVE_No009.Status1 := W#16#0;
   VALVE_No009.Status2 := W#16#0;
   VALVE_No009.Status3 := B#16#0;
   VALVE_No009.InputEdges := B#16#0;
   VALVE_No009.AutoEdges := W#16#0;
   VALVE_No009.DataTimeActFault.StartTime := L#0;
   VALVE_No009.DataTimeActFault.StartEdge := FALSE;
   VALVE_No009.DataTimeOpening.StartTime := L#0;
   VALVE_No009.DataTimeOpening.StartEdge := FALSE;
   VALVE_No009.DataTimeClosing.StartTime := L#0;
   VALVE_No009.DataTimeClosing.StartEdge := FALSE;
   VALVE_No009.DataTimeFeedback.StartTime := L#0;
   VALVE_No009.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No009.DataTimeReverse.StartTime := L#0;
   VALVE_No009.DataTimeReverse.StartEdge := FALSE;
   VALVE_No009.DataTimeOvertravel.StartTime := L#0;
   VALVE_No009.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No009.DataTimeExtFault.StartTime := L#0;
   VALVE_No009.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No009.DataTimeRestart.StartTime := L#0;
   VALVE_No009.DataTimeRestart.StartEdge := FALSE;
   VALVE_No009.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No009.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No009.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No009.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No009.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No009.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No009.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No009.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No009.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No009.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No009.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No009.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No009.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No009.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No009.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No009.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No009.PCONF.DlyTActFault := T#0MS;
   VALVE_No009.PCONF.DlyTOpening := T#0MS;
   VALVE_No009.PCONF.DlyTClosing := T#0MS;
   VALVE_No009.PCONF.DlyTFeedback := T#0MS;
   VALVE_No009.PCONF.DlyTReverse := T#0MS;
   VALVE_No009.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No009.PCONF.DlyTExtFault := T#0MS;
   VALVE_No009.PCONF.DlyTRestart := T#0MS;
   VALVE_No010.System := W#16#0;
   VALVE_No010.CmdOS := W#16#0;
   VALVE_No010.MirrorCmdOS := W#16#0;
   VALVE_No010.Test := W#16#0;
   VALVE_No010.AlarmOS := W#16#0;
   VALVE_No010.StatusOS := W#16#0;
   VALVE_No010.SysStatusOS := W#16#0;
   VALVE_No010.Status1 := W#16#0;
   VALVE_No010.Status2 := W#16#0;
   VALVE_No010.Status3 := B#16#0;
   VALVE_No010.InputEdges := B#16#0;
   VALVE_No010.AutoEdges := W#16#0;
   VALVE_No010.DataTimeActFault.StartTime := L#0;
   VALVE_No010.DataTimeActFault.StartEdge := FALSE;
   VALVE_No010.DataTimeOpening.StartTime := L#0;
   VALVE_No010.DataTimeOpening.StartEdge := FALSE;
   VALVE_No010.DataTimeClosing.StartTime := L#0;
   VALVE_No010.DataTimeClosing.StartEdge := FALSE;
   VALVE_No010.DataTimeFeedback.StartTime := L#0;
   VALVE_No010.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No010.DataTimeReverse.StartTime := L#0;
   VALVE_No010.DataTimeReverse.StartEdge := FALSE;
   VALVE_No010.DataTimeOvertravel.StartTime := L#0;
   VALVE_No010.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No010.DataTimeExtFault.StartTime := L#0;
   VALVE_No010.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No010.DataTimeRestart.StartTime := L#0;
   VALVE_No010.DataTimeRestart.StartEdge := FALSE;
   VALVE_No010.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No010.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No010.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No010.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No010.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No010.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No010.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No010.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No010.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No010.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No010.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No010.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No010.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No010.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No010.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No010.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No010.PCONF.DlyTActFault := T#0MS;
   VALVE_No010.PCONF.DlyTOpening := T#0MS;
   VALVE_No010.PCONF.DlyTClosing := T#0MS;
   VALVE_No010.PCONF.DlyTFeedback := T#0MS;
   VALVE_No010.PCONF.DlyTReverse := T#0MS;
   VALVE_No010.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No010.PCONF.DlyTExtFault := T#0MS;
   VALVE_No010.PCONF.DlyTRestart := T#0MS;
   VALVE_No011.System := W#16#0;
   VALVE_No011.CmdOS := W#16#0;
   VALVE_No011.MirrorCmdOS := W#16#0;
   VALVE_No011.Test := W#16#0;
   VALVE_No011.AlarmOS := W#16#0;
   VALVE_No011.StatusOS := W#16#0;
   VALVE_No011.SysStatusOS := W#16#0;
   VALVE_No011.Status1 := W#16#0;
   VALVE_No011.Status2 := W#16#0;
   VALVE_No011.Status3 := B#16#0;
   VALVE_No011.InputEdges := B#16#0;
   VALVE_No011.AutoEdges := W#16#0;
   VALVE_No011.DataTimeActFault.StartTime := L#0;
   VALVE_No011.DataTimeActFault.StartEdge := FALSE;
   VALVE_No011.DataTimeOpening.StartTime := L#0;
   VALVE_No011.DataTimeOpening.StartEdge := FALSE;
   VALVE_No011.DataTimeClosing.StartTime := L#0;
   VALVE_No011.DataTimeClosing.StartEdge := FALSE;
   VALVE_No011.DataTimeFeedback.StartTime := L#0;
   VALVE_No011.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No011.DataTimeReverse.StartTime := L#0;
   VALVE_No011.DataTimeReverse.StartEdge := FALSE;
   VALVE_No011.DataTimeOvertravel.StartTime := L#0;
   VALVE_No011.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No011.DataTimeExtFault.StartTime := L#0;
   VALVE_No011.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No011.DataTimeRestart.StartTime := L#0;
   VALVE_No011.DataTimeRestart.StartEdge := FALSE;
   VALVE_No011.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No011.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No011.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No011.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No011.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No011.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No011.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No011.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No011.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No011.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No011.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No011.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No011.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No011.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No011.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No011.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No011.PCONF.DlyTActFault := T#0MS;
   VALVE_No011.PCONF.DlyTOpening := T#0MS;
   VALVE_No011.PCONF.DlyTClosing := T#0MS;
   VALVE_No011.PCONF.DlyTFeedback := T#0MS;
   VALVE_No011.PCONF.DlyTReverse := T#0MS;
   VALVE_No011.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No011.PCONF.DlyTExtFault := T#0MS;
   VALVE_No011.PCONF.DlyTRestart := T#0MS;
   VALVE_No012.System := W#16#0;
   VALVE_No012.CmdOS := W#16#0;
   VALVE_No012.MirrorCmdOS := W#16#0;
   VALVE_No012.Test := W#16#0;
   VALVE_No012.AlarmOS := W#16#0;
   VALVE_No012.StatusOS := W#16#0;
   VALVE_No012.SysStatusOS := W#16#0;
   VALVE_No012.Status1 := W#16#0;
   VALVE_No012.Status2 := W#16#0;
   VALVE_No012.Status3 := B#16#0;
   VALVE_No012.InputEdges := B#16#0;
   VALVE_No012.AutoEdges := W#16#0;
   VALVE_No012.DataTimeActFault.StartTime := L#0;
   VALVE_No012.DataTimeActFault.StartEdge := FALSE;
   VALVE_No012.DataTimeOpening.StartTime := L#0;
   VALVE_No012.DataTimeOpening.StartEdge := FALSE;
   VALVE_No012.DataTimeClosing.StartTime := L#0;
   VALVE_No012.DataTimeClosing.StartEdge := FALSE;
   VALVE_No012.DataTimeFeedback.StartTime := L#0;
   VALVE_No012.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No012.DataTimeReverse.StartTime := L#0;
   VALVE_No012.DataTimeReverse.StartEdge := FALSE;
   VALVE_No012.DataTimeOvertravel.StartTime := L#0;
   VALVE_No012.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No012.DataTimeExtFault.StartTime := L#0;
   VALVE_No012.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No012.DataTimeRestart.StartTime := L#0;
   VALVE_No012.DataTimeRestart.StartEdge := FALSE;
   VALVE_No012.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No012.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No012.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No012.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No012.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No012.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No012.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No012.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No012.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No012.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No012.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No012.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No012.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No012.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No012.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No012.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No012.PCONF.DlyTActFault := T#0MS;
   VALVE_No012.PCONF.DlyTOpening := T#0MS;
   VALVE_No012.PCONF.DlyTClosing := T#0MS;
   VALVE_No012.PCONF.DlyTFeedback := T#0MS;
   VALVE_No012.PCONF.DlyTReverse := T#0MS;
   VALVE_No012.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No012.PCONF.DlyTExtFault := T#0MS;
   VALVE_No012.PCONF.DlyTRestart := T#0MS;
   VALVE_No013.System := W#16#0;
   VALVE_No013.CmdOS := W#16#0;
   VALVE_No013.MirrorCmdOS := W#16#0;
   VALVE_No013.Test := W#16#0;
   VALVE_No013.AlarmOS := W#16#0;
   VALVE_No013.StatusOS := W#16#0;
   VALVE_No013.SysStatusOS := W#16#0;
   VALVE_No013.Status1 := W#16#0;
   VALVE_No013.Status2 := W#16#0;
   VALVE_No013.Status3 := B#16#0;
   VALVE_No013.InputEdges := B#16#0;
   VALVE_No013.AutoEdges := W#16#0;
   VALVE_No013.DataTimeActFault.StartTime := L#0;
   VALVE_No013.DataTimeActFault.StartEdge := FALSE;
   VALVE_No013.DataTimeOpening.StartTime := L#0;
   VALVE_No013.DataTimeOpening.StartEdge := FALSE;
   VALVE_No013.DataTimeClosing.StartTime := L#0;
   VALVE_No013.DataTimeClosing.StartEdge := FALSE;
   VALVE_No013.DataTimeFeedback.StartTime := L#0;
   VALVE_No013.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No013.DataTimeReverse.StartTime := L#0;
   VALVE_No013.DataTimeReverse.StartEdge := FALSE;
   VALVE_No013.DataTimeOvertravel.StartTime := L#0;
   VALVE_No013.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No013.DataTimeExtFault.StartTime := L#0;
   VALVE_No013.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No013.DataTimeRestart.StartTime := L#0;
   VALVE_No013.DataTimeRestart.StartEdge := FALSE;
   VALVE_No013.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No013.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No013.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No013.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No013.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No013.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No013.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No013.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No013.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No013.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No013.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No013.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No013.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No013.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No013.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No013.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No013.PCONF.DlyTActFault := T#0MS;
   VALVE_No013.PCONF.DlyTOpening := T#0MS;
   VALVE_No013.PCONF.DlyTClosing := T#0MS;
   VALVE_No013.PCONF.DlyTFeedback := T#0MS;
   VALVE_No013.PCONF.DlyTReverse := T#0MS;
   VALVE_No013.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No013.PCONF.DlyTExtFault := T#0MS;
   VALVE_No013.PCONF.DlyTRestart := T#0MS;
   VALVE_No014.System := W#16#0;
   VALVE_No014.CmdOS := W#16#0;
   VALVE_No014.MirrorCmdOS := W#16#0;
   VALVE_No014.Test := W#16#0;
   VALVE_No014.AlarmOS := W#16#0;
   VALVE_No014.StatusOS := W#16#0;
   VALVE_No014.SysStatusOS := W#16#0;
   VALVE_No014.Status1 := W#16#0;
   VALVE_No014.Status2 := W#16#0;
   VALVE_No014.Status3 := B#16#0;
   VALVE_No014.InputEdges := B#16#0;
   VALVE_No014.AutoEdges := W#16#0;
   VALVE_No014.DataTimeActFault.StartTime := L#0;
   VALVE_No014.DataTimeActFault.StartEdge := FALSE;
   VALVE_No014.DataTimeOpening.StartTime := L#0;
   VALVE_No014.DataTimeOpening.StartEdge := FALSE;
   VALVE_No014.DataTimeClosing.StartTime := L#0;
   VALVE_No014.DataTimeClosing.StartEdge := FALSE;
   VALVE_No014.DataTimeFeedback.StartTime := L#0;
   VALVE_No014.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No014.DataTimeReverse.StartTime := L#0;
   VALVE_No014.DataTimeReverse.StartEdge := FALSE;
   VALVE_No014.DataTimeOvertravel.StartTime := L#0;
   VALVE_No014.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No014.DataTimeExtFault.StartTime := L#0;
   VALVE_No014.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No014.DataTimeRestart.StartTime := L#0;
   VALVE_No014.DataTimeRestart.StartEdge := FALSE;
   VALVE_No014.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No014.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No014.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No014.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No014.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No014.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No014.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No014.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No014.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No014.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No014.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No014.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No014.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No014.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No014.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No014.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No014.PCONF.DlyTActFault := T#0MS;
   VALVE_No014.PCONF.DlyTOpening := T#0MS;
   VALVE_No014.PCONF.DlyTClosing := T#0MS;
   VALVE_No014.PCONF.DlyTFeedback := T#0MS;
   VALVE_No014.PCONF.DlyTReverse := T#0MS;
   VALVE_No014.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No014.PCONF.DlyTExtFault := T#0MS;
   VALVE_No014.PCONF.DlyTRestart := T#0MS;
   VALVE_No015.System := W#16#0;
   VALVE_No015.CmdOS := W#16#0;
   VALVE_No015.MirrorCmdOS := W#16#0;
   VALVE_No015.Test := W#16#0;
   VALVE_No015.AlarmOS := W#16#0;
   VALVE_No015.StatusOS := W#16#0;
   VALVE_No015.SysStatusOS := W#16#0;
   VALVE_No015.Status1 := W#16#0;
   VALVE_No015.Status2 := W#16#0;
   VALVE_No015.Status3 := B#16#0;
   VALVE_No015.InputEdges := B#16#0;
   VALVE_No015.AutoEdges := W#16#0;
   VALVE_No015.DataTimeActFault.StartTime := L#0;
   VALVE_No015.DataTimeActFault.StartEdge := FALSE;
   VALVE_No015.DataTimeOpening.StartTime := L#0;
   VALVE_No015.DataTimeOpening.StartEdge := FALSE;
   VALVE_No015.DataTimeClosing.StartTime := L#0;
   VALVE_No015.DataTimeClosing.StartEdge := FALSE;
   VALVE_No015.DataTimeFeedback.StartTime := L#0;
   VALVE_No015.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No015.DataTimeReverse.StartTime := L#0;
   VALVE_No015.DataTimeReverse.StartEdge := FALSE;
   VALVE_No015.DataTimeOvertravel.StartTime := L#0;
   VALVE_No015.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No015.DataTimeExtFault.StartTime := L#0;
   VALVE_No015.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No015.DataTimeRestart.StartTime := L#0;
   VALVE_No015.DataTimeRestart.StartEdge := FALSE;
   VALVE_No015.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No015.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No015.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No015.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No015.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No015.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No015.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No015.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No015.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No015.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No015.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No015.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No015.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No015.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No015.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No015.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No015.PCONF.DlyTActFault := T#0MS;
   VALVE_No015.PCONF.DlyTOpening := T#0MS;
   VALVE_No015.PCONF.DlyTClosing := T#0MS;
   VALVE_No015.PCONF.DlyTFeedback := T#0MS;
   VALVE_No015.PCONF.DlyTReverse := T#0MS;
   VALVE_No015.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No015.PCONF.DlyTExtFault := T#0MS;
   VALVE_No015.PCONF.DlyTRestart := T#0MS;
   VALVE_No016.System := W#16#0;
   VALVE_No016.CmdOS := W#16#0;
   VALVE_No016.MirrorCmdOS := W#16#0;
   VALVE_No016.Test := W#16#0;
   VALVE_No016.AlarmOS := W#16#0;
   VALVE_No016.StatusOS := W#16#0;
   VALVE_No016.SysStatusOS := W#16#0;
   VALVE_No016.Status1 := W#16#0;
   VALVE_No016.Status2 := W#16#0;
   VALVE_No016.Status3 := B#16#0;
   VALVE_No016.InputEdges := B#16#0;
   VALVE_No016.AutoEdges := W#16#0;
   VALVE_No016.DataTimeActFault.StartTime := L#0;
   VALVE_No016.DataTimeActFault.StartEdge := FALSE;
   VALVE_No016.DataTimeOpening.StartTime := L#0;
   VALVE_No016.DataTimeOpening.StartEdge := FALSE;
   VALVE_No016.DataTimeClosing.StartTime := L#0;
   VALVE_No016.DataTimeClosing.StartEdge := FALSE;
   VALVE_No016.DataTimeFeedback.StartTime := L#0;
   VALVE_No016.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No016.DataTimeReverse.StartTime := L#0;
   VALVE_No016.DataTimeReverse.StartEdge := FALSE;
   VALVE_No016.DataTimeOvertravel.StartTime := L#0;
   VALVE_No016.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No016.DataTimeExtFault.StartTime := L#0;
   VALVE_No016.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No016.DataTimeRestart.StartTime := L#0;
   VALVE_No016.DataTimeRestart.StartEdge := FALSE;
   VALVE_No016.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No016.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No016.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No016.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No016.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No016.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No016.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No016.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No016.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No016.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No016.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No016.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No016.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No016.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No016.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No016.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No016.PCONF.DlyTActFault := T#0MS;
   VALVE_No016.PCONF.DlyTOpening := T#0MS;
   VALVE_No016.PCONF.DlyTClosing := T#0MS;
   VALVE_No016.PCONF.DlyTFeedback := T#0MS;
   VALVE_No016.PCONF.DlyTReverse := T#0MS;
   VALVE_No016.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No016.PCONF.DlyTExtFault := T#0MS;
   VALVE_No016.PCONF.DlyTRestart := T#0MS;
   VALVE_No017.System := W#16#0;
   VALVE_No017.CmdOS := W#16#0;
   VALVE_No017.MirrorCmdOS := W#16#0;
   VALVE_No017.Test := W#16#0;
   VALVE_No017.AlarmOS := W#16#0;
   VALVE_No017.StatusOS := W#16#0;
   VALVE_No017.SysStatusOS := W#16#0;
   VALVE_No017.Status1 := W#16#0;
   VALVE_No017.Status2 := W#16#0;
   VALVE_No017.Status3 := B#16#0;
   VALVE_No017.InputEdges := B#16#0;
   VALVE_No017.AutoEdges := W#16#0;
   VALVE_No017.DataTimeActFault.StartTime := L#0;
   VALVE_No017.DataTimeActFault.StartEdge := FALSE;
   VALVE_No017.DataTimeOpening.StartTime := L#0;
   VALVE_No017.DataTimeOpening.StartEdge := FALSE;
   VALVE_No017.DataTimeClosing.StartTime := L#0;
   VALVE_No017.DataTimeClosing.StartEdge := FALSE;
   VALVE_No017.DataTimeFeedback.StartTime := L#0;
   VALVE_No017.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No017.DataTimeReverse.StartTime := L#0;
   VALVE_No017.DataTimeReverse.StartEdge := FALSE;
   VALVE_No017.DataTimeOvertravel.StartTime := L#0;
   VALVE_No017.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No017.DataTimeExtFault.StartTime := L#0;
   VALVE_No017.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No017.DataTimeRestart.StartTime := L#0;
   VALVE_No017.DataTimeRestart.StartEdge := FALSE;
   VALVE_No017.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No017.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No017.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No017.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No017.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No017.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No017.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No017.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No017.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No017.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No017.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No017.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No017.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No017.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No017.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No017.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No017.PCONF.DlyTActFault := T#0MS;
   VALVE_No017.PCONF.DlyTOpening := T#0MS;
   VALVE_No017.PCONF.DlyTClosing := T#0MS;
   VALVE_No017.PCONF.DlyTFeedback := T#0MS;
   VALVE_No017.PCONF.DlyTReverse := T#0MS;
   VALVE_No017.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No017.PCONF.DlyTExtFault := T#0MS;
   VALVE_No017.PCONF.DlyTRestart := T#0MS;
   VALVE_No018.System := W#16#0;
   VALVE_No018.CmdOS := W#16#0;
   VALVE_No018.MirrorCmdOS := W#16#0;
   VALVE_No018.Test := W#16#0;
   VALVE_No018.AlarmOS := W#16#0;
   VALVE_No018.StatusOS := W#16#0;
   VALVE_No018.SysStatusOS := W#16#0;
   VALVE_No018.Status1 := W#16#0;
   VALVE_No018.Status2 := W#16#0;
   VALVE_No018.Status3 := B#16#0;
   VALVE_No018.InputEdges := B#16#0;
   VALVE_No018.AutoEdges := W#16#0;
   VALVE_No018.DataTimeActFault.StartTime := L#0;
   VALVE_No018.DataTimeActFault.StartEdge := FALSE;
   VALVE_No018.DataTimeOpening.StartTime := L#0;
   VALVE_No018.DataTimeOpening.StartEdge := FALSE;
   VALVE_No018.DataTimeClosing.StartTime := L#0;
   VALVE_No018.DataTimeClosing.StartEdge := FALSE;
   VALVE_No018.DataTimeFeedback.StartTime := L#0;
   VALVE_No018.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No018.DataTimeReverse.StartTime := L#0;
   VALVE_No018.DataTimeReverse.StartEdge := FALSE;
   VALVE_No018.DataTimeOvertravel.StartTime := L#0;
   VALVE_No018.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No018.DataTimeExtFault.StartTime := L#0;
   VALVE_No018.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No018.DataTimeRestart.StartTime := L#0;
   VALVE_No018.DataTimeRestart.StartEdge := FALSE;
   VALVE_No018.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No018.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No018.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No018.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No018.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No018.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No018.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No018.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No018.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No018.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No018.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No018.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No018.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No018.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No018.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No018.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No018.PCONF.DlyTActFault := T#0MS;
   VALVE_No018.PCONF.DlyTOpening := T#0MS;
   VALVE_No018.PCONF.DlyTClosing := T#0MS;
   VALVE_No018.PCONF.DlyTFeedback := T#0MS;
   VALVE_No018.PCONF.DlyTReverse := T#0MS;
   VALVE_No018.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No018.PCONF.DlyTExtFault := T#0MS;
   VALVE_No018.PCONF.DlyTRestart := T#0MS;
   VALVE_No019.System := W#16#0;
   VALVE_No019.CmdOS := W#16#0;
   VALVE_No019.MirrorCmdOS := W#16#0;
   VALVE_No019.Test := W#16#0;
   VALVE_No019.AlarmOS := W#16#0;
   VALVE_No019.StatusOS := W#16#0;
   VALVE_No019.SysStatusOS := W#16#0;
   VALVE_No019.Status1 := W#16#0;
   VALVE_No019.Status2 := W#16#0;
   VALVE_No019.Status3 := B#16#0;
   VALVE_No019.InputEdges := B#16#0;
   VALVE_No019.AutoEdges := W#16#0;
   VALVE_No019.DataTimeActFault.StartTime := L#0;
   VALVE_No019.DataTimeActFault.StartEdge := FALSE;
   VALVE_No019.DataTimeOpening.StartTime := L#0;
   VALVE_No019.DataTimeOpening.StartEdge := FALSE;
   VALVE_No019.DataTimeClosing.StartTime := L#0;
   VALVE_No019.DataTimeClosing.StartEdge := FALSE;
   VALVE_No019.DataTimeFeedback.StartTime := L#0;
   VALVE_No019.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No019.DataTimeReverse.StartTime := L#0;
   VALVE_No019.DataTimeReverse.StartEdge := FALSE;
   VALVE_No019.DataTimeOvertravel.StartTime := L#0;
   VALVE_No019.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No019.DataTimeExtFault.StartTime := L#0;
   VALVE_No019.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No019.DataTimeRestart.StartTime := L#0;
   VALVE_No019.DataTimeRestart.StartEdge := FALSE;
   VALVE_No019.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No019.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No019.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No019.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No019.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No019.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No019.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No019.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No019.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No019.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No019.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No019.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No019.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No019.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No019.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No019.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No019.PCONF.DlyTActFault := T#0MS;
   VALVE_No019.PCONF.DlyTOpening := T#0MS;
   VALVE_No019.PCONF.DlyTClosing := T#0MS;
   VALVE_No019.PCONF.DlyTFeedback := T#0MS;
   VALVE_No019.PCONF.DlyTReverse := T#0MS;
   VALVE_No019.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No019.PCONF.DlyTExtFault := T#0MS;
   VALVE_No019.PCONF.DlyTRestart := T#0MS;
   VALVE_No020.System := W#16#0;
   VALVE_No020.CmdOS := W#16#0;
   VALVE_No020.MirrorCmdOS := W#16#0;
   VALVE_No020.Test := W#16#0;
   VALVE_No020.AlarmOS := W#16#0;
   VALVE_No020.StatusOS := W#16#0;
   VALVE_No020.SysStatusOS := W#16#0;
   VALVE_No020.Status1 := W#16#0;
   VALVE_No020.Status2 := W#16#0;
   VALVE_No020.Status3 := B#16#0;
   VALVE_No020.InputEdges := B#16#0;
   VALVE_No020.AutoEdges := W#16#0;
   VALVE_No020.DataTimeActFault.StartTime := L#0;
   VALVE_No020.DataTimeActFault.StartEdge := FALSE;
   VALVE_No020.DataTimeOpening.StartTime := L#0;
   VALVE_No020.DataTimeOpening.StartEdge := FALSE;
   VALVE_No020.DataTimeClosing.StartTime := L#0;
   VALVE_No020.DataTimeClosing.StartEdge := FALSE;
   VALVE_No020.DataTimeFeedback.StartTime := L#0;
   VALVE_No020.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No020.DataTimeReverse.StartTime := L#0;
   VALVE_No020.DataTimeReverse.StartEdge := FALSE;
   VALVE_No020.DataTimeOvertravel.StartTime := L#0;
   VALVE_No020.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No020.DataTimeExtFault.StartTime := L#0;
   VALVE_No020.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No020.DataTimeRestart.StartTime := L#0;
   VALVE_No020.DataTimeRestart.StartEdge := FALSE;
   VALVE_No020.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No020.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No020.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No020.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No020.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No020.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No020.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No020.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No020.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No020.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No020.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No020.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No020.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No020.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No020.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No020.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No020.PCONF.DlyTActFault := T#0MS;
   VALVE_No020.PCONF.DlyTOpening := T#0MS;
   VALVE_No020.PCONF.DlyTClosing := T#0MS;
   VALVE_No020.PCONF.DlyTFeedback := T#0MS;
   VALVE_No020.PCONF.DlyTReverse := T#0MS;
   VALVE_No020.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No020.PCONF.DlyTExtFault := T#0MS;
   VALVE_No020.PCONF.DlyTRestart := T#0MS;
   VALVE_No021.System := W#16#0;
   VALVE_No021.CmdOS := W#16#0;
   VALVE_No021.MirrorCmdOS := W#16#0;
   VALVE_No021.Test := W#16#0;
   VALVE_No021.AlarmOS := W#16#0;
   VALVE_No021.StatusOS := W#16#0;
   VALVE_No021.SysStatusOS := W#16#0;
   VALVE_No021.Status1 := W#16#0;
   VALVE_No021.Status2 := W#16#0;
   VALVE_No021.Status3 := B#16#0;
   VALVE_No021.InputEdges := B#16#0;
   VALVE_No021.AutoEdges := W#16#0;
   VALVE_No021.DataTimeActFault.StartTime := L#0;
   VALVE_No021.DataTimeActFault.StartEdge := FALSE;
   VALVE_No021.DataTimeOpening.StartTime := L#0;
   VALVE_No021.DataTimeOpening.StartEdge := FALSE;
   VALVE_No021.DataTimeClosing.StartTime := L#0;
   VALVE_No021.DataTimeClosing.StartEdge := FALSE;
   VALVE_No021.DataTimeFeedback.StartTime := L#0;
   VALVE_No021.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No021.DataTimeReverse.StartTime := L#0;
   VALVE_No021.DataTimeReverse.StartEdge := FALSE;
   VALVE_No021.DataTimeOvertravel.StartTime := L#0;
   VALVE_No021.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No021.DataTimeExtFault.StartTime := L#0;
   VALVE_No021.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No021.DataTimeRestart.StartTime := L#0;
   VALVE_No021.DataTimeRestart.StartEdge := FALSE;
   VALVE_No021.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No021.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No021.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No021.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No021.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No021.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No021.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No021.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No021.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No021.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No021.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No021.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No021.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No021.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No021.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No021.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No021.PCONF.DlyTActFault := T#0MS;
   VALVE_No021.PCONF.DlyTOpening := T#0MS;
   VALVE_No021.PCONF.DlyTClosing := T#0MS;
   VALVE_No021.PCONF.DlyTFeedback := T#0MS;
   VALVE_No021.PCONF.DlyTReverse := T#0MS;
   VALVE_No021.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No021.PCONF.DlyTExtFault := T#0MS;
   VALVE_No021.PCONF.DlyTRestart := T#0MS;
   VALVE_No022.System := W#16#0;
   VALVE_No022.CmdOS := W#16#0;
   VALVE_No022.MirrorCmdOS := W#16#0;
   VALVE_No022.Test := W#16#0;
   VALVE_No022.AlarmOS := W#16#0;
   VALVE_No022.StatusOS := W#16#0;
   VALVE_No022.SysStatusOS := W#16#0;
   VALVE_No022.Status1 := W#16#0;
   VALVE_No022.Status2 := W#16#0;
   VALVE_No022.Status3 := B#16#0;
   VALVE_No022.InputEdges := B#16#0;
   VALVE_No022.AutoEdges := W#16#0;
   VALVE_No022.DataTimeActFault.StartTime := L#0;
   VALVE_No022.DataTimeActFault.StartEdge := FALSE;
   VALVE_No022.DataTimeOpening.StartTime := L#0;
   VALVE_No022.DataTimeOpening.StartEdge := FALSE;
   VALVE_No022.DataTimeClosing.StartTime := L#0;
   VALVE_No022.DataTimeClosing.StartEdge := FALSE;
   VALVE_No022.DataTimeFeedback.StartTime := L#0;
   VALVE_No022.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No022.DataTimeReverse.StartTime := L#0;
   VALVE_No022.DataTimeReverse.StartEdge := FALSE;
   VALVE_No022.DataTimeOvertravel.StartTime := L#0;
   VALVE_No022.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No022.DataTimeExtFault.StartTime := L#0;
   VALVE_No022.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No022.DataTimeRestart.StartTime := L#0;
   VALVE_No022.DataTimeRestart.StartEdge := FALSE;
   VALVE_No022.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No022.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No022.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No022.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No022.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No022.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No022.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No022.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No022.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No022.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No022.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No022.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No022.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No022.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No022.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No022.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No022.PCONF.DlyTActFault := T#0MS;
   VALVE_No022.PCONF.DlyTOpening := T#0MS;
   VALVE_No022.PCONF.DlyTClosing := T#0MS;
   VALVE_No022.PCONF.DlyTFeedback := T#0MS;
   VALVE_No022.PCONF.DlyTReverse := T#0MS;
   VALVE_No022.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No022.PCONF.DlyTExtFault := T#0MS;
   VALVE_No022.PCONF.DlyTRestart := T#0MS;
   VALVE_No023.System := W#16#0;
   VALVE_No023.CmdOS := W#16#0;
   VALVE_No023.MirrorCmdOS := W#16#0;
   VALVE_No023.Test := W#16#0;
   VALVE_No023.AlarmOS := W#16#0;
   VALVE_No023.StatusOS := W#16#0;
   VALVE_No023.SysStatusOS := W#16#0;
   VALVE_No023.Status1 := W#16#0;
   VALVE_No023.Status2 := W#16#0;
   VALVE_No023.Status3 := B#16#0;
   VALVE_No023.InputEdges := B#16#0;
   VALVE_No023.AutoEdges := W#16#0;
   VALVE_No023.DataTimeActFault.StartTime := L#0;
   VALVE_No023.DataTimeActFault.StartEdge := FALSE;
   VALVE_No023.DataTimeOpening.StartTime := L#0;
   VALVE_No023.DataTimeOpening.StartEdge := FALSE;
   VALVE_No023.DataTimeClosing.StartTime := L#0;
   VALVE_No023.DataTimeClosing.StartEdge := FALSE;
   VALVE_No023.DataTimeFeedback.StartTime := L#0;
   VALVE_No023.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No023.DataTimeReverse.StartTime := L#0;
   VALVE_No023.DataTimeReverse.StartEdge := FALSE;
   VALVE_No023.DataTimeOvertravel.StartTime := L#0;
   VALVE_No023.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No023.DataTimeExtFault.StartTime := L#0;
   VALVE_No023.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No023.DataTimeRestart.StartTime := L#0;
   VALVE_No023.DataTimeRestart.StartEdge := FALSE;
   VALVE_No023.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No023.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No023.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No023.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No023.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No023.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No023.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No023.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No023.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No023.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No023.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No023.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No023.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No023.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No023.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No023.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No023.PCONF.DlyTActFault := T#0MS;
   VALVE_No023.PCONF.DlyTOpening := T#0MS;
   VALVE_No023.PCONF.DlyTClosing := T#0MS;
   VALVE_No023.PCONF.DlyTFeedback := T#0MS;
   VALVE_No023.PCONF.DlyTReverse := T#0MS;
   VALVE_No023.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No023.PCONF.DlyTExtFault := T#0MS;
   VALVE_No023.PCONF.DlyTRestart := T#0MS;
   VALVE_No024.System := W#16#0;
   VALVE_No024.CmdOS := W#16#0;
   VALVE_No024.MirrorCmdOS := W#16#0;
   VALVE_No024.Test := W#16#0;
   VALVE_No024.AlarmOS := W#16#0;
   VALVE_No024.StatusOS := W#16#0;
   VALVE_No024.SysStatusOS := W#16#0;
   VALVE_No024.Status1 := W#16#0;
   VALVE_No024.Status2 := W#16#0;
   VALVE_No024.Status3 := B#16#0;
   VALVE_No024.InputEdges := B#16#0;
   VALVE_No024.AutoEdges := W#16#0;
   VALVE_No024.DataTimeActFault.StartTime := L#0;
   VALVE_No024.DataTimeActFault.StartEdge := FALSE;
   VALVE_No024.DataTimeOpening.StartTime := L#0;
   VALVE_No024.DataTimeOpening.StartEdge := FALSE;
   VALVE_No024.DataTimeClosing.StartTime := L#0;
   VALVE_No024.DataTimeClosing.StartEdge := FALSE;
   VALVE_No024.DataTimeFeedback.StartTime := L#0;
   VALVE_No024.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No024.DataTimeReverse.StartTime := L#0;
   VALVE_No024.DataTimeReverse.StartEdge := FALSE;
   VALVE_No024.DataTimeOvertravel.StartTime := L#0;
   VALVE_No024.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No024.DataTimeExtFault.StartTime := L#0;
   VALVE_No024.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No024.DataTimeRestart.StartTime := L#0;
   VALVE_No024.DataTimeRestart.StartEdge := FALSE;
   VALVE_No024.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No024.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No024.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No024.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No024.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No024.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No024.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No024.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No024.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No024.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No024.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No024.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No024.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No024.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No024.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No024.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No024.PCONF.DlyTActFault := T#0MS;
   VALVE_No024.PCONF.DlyTOpening := T#0MS;
   VALVE_No024.PCONF.DlyTClosing := T#0MS;
   VALVE_No024.PCONF.DlyTFeedback := T#0MS;
   VALVE_No024.PCONF.DlyTReverse := T#0MS;
   VALVE_No024.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No024.PCONF.DlyTExtFault := T#0MS;
   VALVE_No024.PCONF.DlyTRestart := T#0MS;
   VALVE_No025.System := W#16#0;
   VALVE_No025.CmdOS := W#16#0;
   VALVE_No025.MirrorCmdOS := W#16#0;
   VALVE_No025.Test := W#16#0;
   VALVE_No025.AlarmOS := W#16#0;
   VALVE_No025.StatusOS := W#16#0;
   VALVE_No025.SysStatusOS := W#16#0;
   VALVE_No025.Status1 := W#16#0;
   VALVE_No025.Status2 := W#16#0;
   VALVE_No025.Status3 := B#16#0;
   VALVE_No025.InputEdges := B#16#0;
   VALVE_No025.AutoEdges := W#16#0;
   VALVE_No025.DataTimeActFault.StartTime := L#0;
   VALVE_No025.DataTimeActFault.StartEdge := FALSE;
   VALVE_No025.DataTimeOpening.StartTime := L#0;
   VALVE_No025.DataTimeOpening.StartEdge := FALSE;
   VALVE_No025.DataTimeClosing.StartTime := L#0;
   VALVE_No025.DataTimeClosing.StartEdge := FALSE;
   VALVE_No025.DataTimeFeedback.StartTime := L#0;
   VALVE_No025.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No025.DataTimeReverse.StartTime := L#0;
   VALVE_No025.DataTimeReverse.StartEdge := FALSE;
   VALVE_No025.DataTimeOvertravel.StartTime := L#0;
   VALVE_No025.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No025.DataTimeExtFault.StartTime := L#0;
   VALVE_No025.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No025.DataTimeRestart.StartTime := L#0;
   VALVE_No025.DataTimeRestart.StartEdge := FALSE;
   VALVE_No025.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No025.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No025.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No025.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No025.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No025.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No025.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No025.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No025.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No025.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No025.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No025.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No025.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No025.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No025.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No025.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No025.PCONF.DlyTActFault := T#0MS;
   VALVE_No025.PCONF.DlyTOpening := T#0MS;
   VALVE_No025.PCONF.DlyTClosing := T#0MS;
   VALVE_No025.PCONF.DlyTFeedback := T#0MS;
   VALVE_No025.PCONF.DlyTReverse := T#0MS;
   VALVE_No025.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No025.PCONF.DlyTExtFault := T#0MS;
   VALVE_No025.PCONF.DlyTRestart := T#0MS;
   VALVE_No026.System := W#16#0;
   VALVE_No026.CmdOS := W#16#0;
   VALVE_No026.MirrorCmdOS := W#16#0;
   VALVE_No026.Test := W#16#0;
   VALVE_No026.AlarmOS := W#16#0;
   VALVE_No026.StatusOS := W#16#0;
   VALVE_No026.SysStatusOS := W#16#0;
   VALVE_No026.Status1 := W#16#0;
   VALVE_No026.Status2 := W#16#0;
   VALVE_No026.Status3 := B#16#0;
   VALVE_No026.InputEdges := B#16#0;
   VALVE_No026.AutoEdges := W#16#0;
   VALVE_No026.DataTimeActFault.StartTime := L#0;
   VALVE_No026.DataTimeActFault.StartEdge := FALSE;
   VALVE_No026.DataTimeOpening.StartTime := L#0;
   VALVE_No026.DataTimeOpening.StartEdge := FALSE;
   VALVE_No026.DataTimeClosing.StartTime := L#0;
   VALVE_No026.DataTimeClosing.StartEdge := FALSE;
   VALVE_No026.DataTimeFeedback.StartTime := L#0;
   VALVE_No026.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No026.DataTimeReverse.StartTime := L#0;
   VALVE_No026.DataTimeReverse.StartEdge := FALSE;
   VALVE_No026.DataTimeOvertravel.StartTime := L#0;
   VALVE_No026.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No026.DataTimeExtFault.StartTime := L#0;
   VALVE_No026.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No026.DataTimeRestart.StartTime := L#0;
   VALVE_No026.DataTimeRestart.StartEdge := FALSE;
   VALVE_No026.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No026.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No026.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No026.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No026.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No026.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No026.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No026.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No026.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No026.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No026.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No026.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No026.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No026.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No026.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No026.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No026.PCONF.DlyTActFault := T#0MS;
   VALVE_No026.PCONF.DlyTOpening := T#0MS;
   VALVE_No026.PCONF.DlyTClosing := T#0MS;
   VALVE_No026.PCONF.DlyTFeedback := T#0MS;
   VALVE_No026.PCONF.DlyTReverse := T#0MS;
   VALVE_No026.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No026.PCONF.DlyTExtFault := T#0MS;
   VALVE_No026.PCONF.DlyTRestart := T#0MS;
   VALVE_No027.System := W#16#0;
   VALVE_No027.CmdOS := W#16#0;
   VALVE_No027.MirrorCmdOS := W#16#0;
   VALVE_No027.Test := W#16#0;
   VALVE_No027.AlarmOS := W#16#0;
   VALVE_No027.StatusOS := W#16#0;
   VALVE_No027.SysStatusOS := W#16#0;
   VALVE_No027.Status1 := W#16#0;
   VALVE_No027.Status2 := W#16#0;
   VALVE_No027.Status3 := B#16#0;
   VALVE_No027.InputEdges := B#16#0;
   VALVE_No027.AutoEdges := W#16#0;
   VALVE_No027.DataTimeActFault.StartTime := L#0;
   VALVE_No027.DataTimeActFault.StartEdge := FALSE;
   VALVE_No027.DataTimeOpening.StartTime := L#0;
   VALVE_No027.DataTimeOpening.StartEdge := FALSE;
   VALVE_No027.DataTimeClosing.StartTime := L#0;
   VALVE_No027.DataTimeClosing.StartEdge := FALSE;
   VALVE_No027.DataTimeFeedback.StartTime := L#0;
   VALVE_No027.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No027.DataTimeReverse.StartTime := L#0;
   VALVE_No027.DataTimeReverse.StartEdge := FALSE;
   VALVE_No027.DataTimeOvertravel.StartTime := L#0;
   VALVE_No027.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No027.DataTimeExtFault.StartTime := L#0;
   VALVE_No027.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No027.DataTimeRestart.StartTime := L#0;
   VALVE_No027.DataTimeRestart.StartEdge := FALSE;
   VALVE_No027.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No027.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No027.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No027.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No027.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No027.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No027.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No027.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No027.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No027.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No027.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No027.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No027.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No027.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No027.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No027.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No027.PCONF.DlyTActFault := T#0MS;
   VALVE_No027.PCONF.DlyTOpening := T#0MS;
   VALVE_No027.PCONF.DlyTClosing := T#0MS;
   VALVE_No027.PCONF.DlyTFeedback := T#0MS;
   VALVE_No027.PCONF.DlyTReverse := T#0MS;
   VALVE_No027.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No027.PCONF.DlyTExtFault := T#0MS;
   VALVE_No027.PCONF.DlyTRestart := T#0MS;
   VALVE_No028.System := W#16#0;
   VALVE_No028.CmdOS := W#16#0;
   VALVE_No028.MirrorCmdOS := W#16#0;
   VALVE_No028.Test := W#16#0;
   VALVE_No028.AlarmOS := W#16#0;
   VALVE_No028.StatusOS := W#16#0;
   VALVE_No028.SysStatusOS := W#16#0;
   VALVE_No028.Status1 := W#16#0;
   VALVE_No028.Status2 := W#16#0;
   VALVE_No028.Status3 := B#16#0;
   VALVE_No028.InputEdges := B#16#0;
   VALVE_No028.AutoEdges := W#16#0;
   VALVE_No028.DataTimeActFault.StartTime := L#0;
   VALVE_No028.DataTimeActFault.StartEdge := FALSE;
   VALVE_No028.DataTimeOpening.StartTime := L#0;
   VALVE_No028.DataTimeOpening.StartEdge := FALSE;
   VALVE_No028.DataTimeClosing.StartTime := L#0;
   VALVE_No028.DataTimeClosing.StartEdge := FALSE;
   VALVE_No028.DataTimeFeedback.StartTime := L#0;
   VALVE_No028.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No028.DataTimeReverse.StartTime := L#0;
   VALVE_No028.DataTimeReverse.StartEdge := FALSE;
   VALVE_No028.DataTimeOvertravel.StartTime := L#0;
   VALVE_No028.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No028.DataTimeExtFault.StartTime := L#0;
   VALVE_No028.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No028.DataTimeRestart.StartTime := L#0;
   VALVE_No028.DataTimeRestart.StartEdge := FALSE;
   VALVE_No028.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No028.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No028.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No028.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No028.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No028.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No028.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No028.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No028.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No028.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No028.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No028.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No028.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No028.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No028.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No028.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No028.PCONF.DlyTActFault := T#0MS;
   VALVE_No028.PCONF.DlyTOpening := T#0MS;
   VALVE_No028.PCONF.DlyTClosing := T#0MS;
   VALVE_No028.PCONF.DlyTFeedback := T#0MS;
   VALVE_No028.PCONF.DlyTReverse := T#0MS;
   VALVE_No028.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No028.PCONF.DlyTExtFault := T#0MS;
   VALVE_No028.PCONF.DlyTRestart := T#0MS;
   VALVE_No029.System := W#16#0;
   VALVE_No029.CmdOS := W#16#0;
   VALVE_No029.MirrorCmdOS := W#16#0;
   VALVE_No029.Test := W#16#0;
   VALVE_No029.AlarmOS := W#16#0;
   VALVE_No029.StatusOS := W#16#0;
   VALVE_No029.SysStatusOS := W#16#0;
   VALVE_No029.Status1 := W#16#0;
   VALVE_No029.Status2 := W#16#0;
   VALVE_No029.Status3 := B#16#0;
   VALVE_No029.InputEdges := B#16#0;
   VALVE_No029.AutoEdges := W#16#0;
   VALVE_No029.DataTimeActFault.StartTime := L#0;
   VALVE_No029.DataTimeActFault.StartEdge := FALSE;
   VALVE_No029.DataTimeOpening.StartTime := L#0;
   VALVE_No029.DataTimeOpening.StartEdge := FALSE;
   VALVE_No029.DataTimeClosing.StartTime := L#0;
   VALVE_No029.DataTimeClosing.StartEdge := FALSE;
   VALVE_No029.DataTimeFeedback.StartTime := L#0;
   VALVE_No029.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No029.DataTimeReverse.StartTime := L#0;
   VALVE_No029.DataTimeReverse.StartEdge := FALSE;
   VALVE_No029.DataTimeOvertravel.StartTime := L#0;
   VALVE_No029.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No029.DataTimeExtFault.StartTime := L#0;
   VALVE_No029.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No029.DataTimeRestart.StartTime := L#0;
   VALVE_No029.DataTimeRestart.StartEdge := FALSE;
   VALVE_No029.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No029.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No029.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No029.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No029.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No029.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No029.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No029.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No029.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No029.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No029.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No029.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No029.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No029.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No029.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No029.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No029.PCONF.DlyTActFault := T#0MS;
   VALVE_No029.PCONF.DlyTOpening := T#0MS;
   VALVE_No029.PCONF.DlyTClosing := T#0MS;
   VALVE_No029.PCONF.DlyTFeedback := T#0MS;
   VALVE_No029.PCONF.DlyTReverse := T#0MS;
   VALVE_No029.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No029.PCONF.DlyTExtFault := T#0MS;
   VALVE_No029.PCONF.DlyTRestart := T#0MS;
   VALVE_No030.System := W#16#0;
   VALVE_No030.CmdOS := W#16#0;
   VALVE_No030.MirrorCmdOS := W#16#0;
   VALVE_No030.Test := W#16#0;
   VALVE_No030.AlarmOS := W#16#0;
   VALVE_No030.StatusOS := W#16#0;
   VALVE_No030.SysStatusOS := W#16#0;
   VALVE_No030.Status1 := W#16#0;
   VALVE_No030.Status2 := W#16#0;
   VALVE_No030.Status3 := B#16#0;
   VALVE_No030.InputEdges := B#16#0;
   VALVE_No030.AutoEdges := W#16#0;
   VALVE_No030.DataTimeActFault.StartTime := L#0;
   VALVE_No030.DataTimeActFault.StartEdge := FALSE;
   VALVE_No030.DataTimeOpening.StartTime := L#0;
   VALVE_No030.DataTimeOpening.StartEdge := FALSE;
   VALVE_No030.DataTimeClosing.StartTime := L#0;
   VALVE_No030.DataTimeClosing.StartEdge := FALSE;
   VALVE_No030.DataTimeFeedback.StartTime := L#0;
   VALVE_No030.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No030.DataTimeReverse.StartTime := L#0;
   VALVE_No030.DataTimeReverse.StartEdge := FALSE;
   VALVE_No030.DataTimeOvertravel.StartTime := L#0;
   VALVE_No030.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No030.DataTimeExtFault.StartTime := L#0;
   VALVE_No030.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No030.DataTimeRestart.StartTime := L#0;
   VALVE_No030.DataTimeRestart.StartEdge := FALSE;
   VALVE_No030.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No030.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No030.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No030.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No030.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No030.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No030.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No030.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No030.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No030.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No030.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No030.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No030.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No030.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No030.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No030.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No030.PCONF.DlyTActFault := T#0MS;
   VALVE_No030.PCONF.DlyTOpening := T#0MS;
   VALVE_No030.PCONF.DlyTClosing := T#0MS;
   VALVE_No030.PCONF.DlyTFeedback := T#0MS;
   VALVE_No030.PCONF.DlyTReverse := T#0MS;
   VALVE_No030.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No030.PCONF.DlyTExtFault := T#0MS;
   VALVE_No030.PCONF.DlyTRestart := T#0MS;
   VALVE_No031.System := W#16#0;
   VALVE_No031.CmdOS := W#16#0;
   VALVE_No031.MirrorCmdOS := W#16#0;
   VALVE_No031.Test := W#16#0;
   VALVE_No031.AlarmOS := W#16#0;
   VALVE_No031.StatusOS := W#16#0;
   VALVE_No031.SysStatusOS := W#16#0;
   VALVE_No031.Status1 := W#16#0;
   VALVE_No031.Status2 := W#16#0;
   VALVE_No031.Status3 := B#16#0;
   VALVE_No031.InputEdges := B#16#0;
   VALVE_No031.AutoEdges := W#16#0;
   VALVE_No031.DataTimeActFault.StartTime := L#0;
   VALVE_No031.DataTimeActFault.StartEdge := FALSE;
   VALVE_No031.DataTimeOpening.StartTime := L#0;
   VALVE_No031.DataTimeOpening.StartEdge := FALSE;
   VALVE_No031.DataTimeClosing.StartTime := L#0;
   VALVE_No031.DataTimeClosing.StartEdge := FALSE;
   VALVE_No031.DataTimeFeedback.StartTime := L#0;
   VALVE_No031.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No031.DataTimeReverse.StartTime := L#0;
   VALVE_No031.DataTimeReverse.StartEdge := FALSE;
   VALVE_No031.DataTimeOvertravel.StartTime := L#0;
   VALVE_No031.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No031.DataTimeExtFault.StartTime := L#0;
   VALVE_No031.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No031.DataTimeRestart.StartTime := L#0;
   VALVE_No031.DataTimeRestart.StartEdge := FALSE;
   VALVE_No031.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No031.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No031.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No031.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No031.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No031.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No031.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No031.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No031.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No031.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No031.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No031.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No031.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No031.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No031.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No031.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No031.PCONF.DlyTActFault := T#0MS;
   VALVE_No031.PCONF.DlyTOpening := T#0MS;
   VALVE_No031.PCONF.DlyTClosing := T#0MS;
   VALVE_No031.PCONF.DlyTFeedback := T#0MS;
   VALVE_No031.PCONF.DlyTReverse := T#0MS;
   VALVE_No031.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No031.PCONF.DlyTExtFault := T#0MS;
   VALVE_No031.PCONF.DlyTRestart := T#0MS;
   VALVE_No032.System := W#16#0;
   VALVE_No032.CmdOS := W#16#0;
   VALVE_No032.MirrorCmdOS := W#16#0;
   VALVE_No032.Test := W#16#0;
   VALVE_No032.AlarmOS := W#16#0;
   VALVE_No032.StatusOS := W#16#0;
   VALVE_No032.SysStatusOS := W#16#0;
   VALVE_No032.Status1 := W#16#0;
   VALVE_No032.Status2 := W#16#0;
   VALVE_No032.Status3 := B#16#0;
   VALVE_No032.InputEdges := B#16#0;
   VALVE_No032.AutoEdges := W#16#0;
   VALVE_No032.DataTimeActFault.StartTime := L#0;
   VALVE_No032.DataTimeActFault.StartEdge := FALSE;
   VALVE_No032.DataTimeOpening.StartTime := L#0;
   VALVE_No032.DataTimeOpening.StartEdge := FALSE;
   VALVE_No032.DataTimeClosing.StartTime := L#0;
   VALVE_No032.DataTimeClosing.StartEdge := FALSE;
   VALVE_No032.DataTimeFeedback.StartTime := L#0;
   VALVE_No032.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No032.DataTimeReverse.StartTime := L#0;
   VALVE_No032.DataTimeReverse.StartEdge := FALSE;
   VALVE_No032.DataTimeOvertravel.StartTime := L#0;
   VALVE_No032.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No032.DataTimeExtFault.StartTime := L#0;
   VALVE_No032.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No032.DataTimeRestart.StartTime := L#0;
   VALVE_No032.DataTimeRestart.StartEdge := FALSE;
   VALVE_No032.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No032.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No032.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No032.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No032.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No032.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No032.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No032.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No032.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No032.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No032.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No032.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No032.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No032.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No032.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No032.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No032.PCONF.DlyTActFault := T#0MS;
   VALVE_No032.PCONF.DlyTOpening := T#0MS;
   VALVE_No032.PCONF.DlyTClosing := T#0MS;
   VALVE_No032.PCONF.DlyTFeedback := T#0MS;
   VALVE_No032.PCONF.DlyTReverse := T#0MS;
   VALVE_No032.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No032.PCONF.DlyTExtFault := T#0MS;
   VALVE_No032.PCONF.DlyTRestart := T#0MS;
   VALVE_No033.System := W#16#0;
   VALVE_No033.CmdOS := W#16#0;
   VALVE_No033.MirrorCmdOS := W#16#0;
   VALVE_No033.Test := W#16#0;
   VALVE_No033.AlarmOS := W#16#0;
   VALVE_No033.StatusOS := W#16#0;
   VALVE_No033.SysStatusOS := W#16#0;
   VALVE_No033.Status1 := W#16#0;
   VALVE_No033.Status2 := W#16#0;
   VALVE_No033.Status3 := B#16#0;
   VALVE_No033.InputEdges := B#16#0;
   VALVE_No033.AutoEdges := W#16#0;
   VALVE_No033.DataTimeActFault.StartTime := L#0;
   VALVE_No033.DataTimeActFault.StartEdge := FALSE;
   VALVE_No033.DataTimeOpening.StartTime := L#0;
   VALVE_No033.DataTimeOpening.StartEdge := FALSE;
   VALVE_No033.DataTimeClosing.StartTime := L#0;
   VALVE_No033.DataTimeClosing.StartEdge := FALSE;
   VALVE_No033.DataTimeFeedback.StartTime := L#0;
   VALVE_No033.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No033.DataTimeReverse.StartTime := L#0;
   VALVE_No033.DataTimeReverse.StartEdge := FALSE;
   VALVE_No033.DataTimeOvertravel.StartTime := L#0;
   VALVE_No033.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No033.DataTimeExtFault.StartTime := L#0;
   VALVE_No033.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No033.DataTimeRestart.StartTime := L#0;
   VALVE_No033.DataTimeRestart.StartEdge := FALSE;
   VALVE_No033.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No033.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No033.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No033.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No033.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No033.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No033.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No033.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No033.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No033.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No033.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No033.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No033.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No033.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No033.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No033.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No033.PCONF.DlyTActFault := T#0MS;
   VALVE_No033.PCONF.DlyTOpening := T#0MS;
   VALVE_No033.PCONF.DlyTClosing := T#0MS;
   VALVE_No033.PCONF.DlyTFeedback := T#0MS;
   VALVE_No033.PCONF.DlyTReverse := T#0MS;
   VALVE_No033.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No033.PCONF.DlyTExtFault := T#0MS;
   VALVE_No033.PCONF.DlyTRestart := T#0MS;
   VALVE_No034.System := W#16#0;
   VALVE_No034.CmdOS := W#16#0;
   VALVE_No034.MirrorCmdOS := W#16#0;
   VALVE_No034.Test := W#16#0;
   VALVE_No034.AlarmOS := W#16#0;
   VALVE_No034.StatusOS := W#16#0;
   VALVE_No034.SysStatusOS := W#16#0;
   VALVE_No034.Status1 := W#16#0;
   VALVE_No034.Status2 := W#16#0;
   VALVE_No034.Status3 := B#16#0;
   VALVE_No034.InputEdges := B#16#0;
   VALVE_No034.AutoEdges := W#16#0;
   VALVE_No034.DataTimeActFault.StartTime := L#0;
   VALVE_No034.DataTimeActFault.StartEdge := FALSE;
   VALVE_No034.DataTimeOpening.StartTime := L#0;
   VALVE_No034.DataTimeOpening.StartEdge := FALSE;
   VALVE_No034.DataTimeClosing.StartTime := L#0;
   VALVE_No034.DataTimeClosing.StartEdge := FALSE;
   VALVE_No034.DataTimeFeedback.StartTime := L#0;
   VALVE_No034.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No034.DataTimeReverse.StartTime := L#0;
   VALVE_No034.DataTimeReverse.StartEdge := FALSE;
   VALVE_No034.DataTimeOvertravel.StartTime := L#0;
   VALVE_No034.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No034.DataTimeExtFault.StartTime := L#0;
   VALVE_No034.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No034.DataTimeRestart.StartTime := L#0;
   VALVE_No034.DataTimeRestart.StartEdge := FALSE;
   VALVE_No034.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No034.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No034.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No034.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No034.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No034.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No034.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No034.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No034.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No034.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No034.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No034.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No034.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No034.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No034.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No034.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No034.PCONF.DlyTActFault := T#0MS;
   VALVE_No034.PCONF.DlyTOpening := T#0MS;
   VALVE_No034.PCONF.DlyTClosing := T#0MS;
   VALVE_No034.PCONF.DlyTFeedback := T#0MS;
   VALVE_No034.PCONF.DlyTReverse := T#0MS;
   VALVE_No034.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No034.PCONF.DlyTExtFault := T#0MS;
   VALVE_No034.PCONF.DlyTRestart := T#0MS;
   VALVE_No035.System := W#16#0;
   VALVE_No035.CmdOS := W#16#0;
   VALVE_No035.MirrorCmdOS := W#16#0;
   VALVE_No035.Test := W#16#0;
   VALVE_No035.AlarmOS := W#16#0;
   VALVE_No035.StatusOS := W#16#0;
   VALVE_No035.SysStatusOS := W#16#0;
   VALVE_No035.Status1 := W#16#0;
   VALVE_No035.Status2 := W#16#0;
   VALVE_No035.Status3 := B#16#0;
   VALVE_No035.InputEdges := B#16#0;
   VALVE_No035.AutoEdges := W#16#0;
   VALVE_No035.DataTimeActFault.StartTime := L#0;
   VALVE_No035.DataTimeActFault.StartEdge := FALSE;
   VALVE_No035.DataTimeOpening.StartTime := L#0;
   VALVE_No035.DataTimeOpening.StartEdge := FALSE;
   VALVE_No035.DataTimeClosing.StartTime := L#0;
   VALVE_No035.DataTimeClosing.StartEdge := FALSE;
   VALVE_No035.DataTimeFeedback.StartTime := L#0;
   VALVE_No035.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No035.DataTimeReverse.StartTime := L#0;
   VALVE_No035.DataTimeReverse.StartEdge := FALSE;
   VALVE_No035.DataTimeOvertravel.StartTime := L#0;
   VALVE_No035.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No035.DataTimeExtFault.StartTime := L#0;
   VALVE_No035.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No035.DataTimeRestart.StartTime := L#0;
   VALVE_No035.DataTimeRestart.StartEdge := FALSE;
   VALVE_No035.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No035.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No035.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No035.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No035.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No035.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No035.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No035.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No035.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No035.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No035.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No035.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No035.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No035.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No035.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No035.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No035.PCONF.DlyTActFault := T#0MS;
   VALVE_No035.PCONF.DlyTOpening := T#0MS;
   VALVE_No035.PCONF.DlyTClosing := T#0MS;
   VALVE_No035.PCONF.DlyTFeedback := T#0MS;
   VALVE_No035.PCONF.DlyTReverse := T#0MS;
   VALVE_No035.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No035.PCONF.DlyTExtFault := T#0MS;
   VALVE_No035.PCONF.DlyTRestart := T#0MS;
   VALVE_No036.System := W#16#0;
   VALVE_No036.CmdOS := W#16#0;
   VALVE_No036.MirrorCmdOS := W#16#0;
   VALVE_No036.Test := W#16#0;
   VALVE_No036.AlarmOS := W#16#0;
   VALVE_No036.StatusOS := W#16#0;
   VALVE_No036.SysStatusOS := W#16#0;
   VALVE_No036.Status1 := W#16#0;
   VALVE_No036.Status2 := W#16#0;
   VALVE_No036.Status3 := B#16#0;
   VALVE_No036.InputEdges := B#16#0;
   VALVE_No036.AutoEdges := W#16#0;
   VALVE_No036.DataTimeActFault.StartTime := L#0;
   VALVE_No036.DataTimeActFault.StartEdge := FALSE;
   VALVE_No036.DataTimeOpening.StartTime := L#0;
   VALVE_No036.DataTimeOpening.StartEdge := FALSE;
   VALVE_No036.DataTimeClosing.StartTime := L#0;
   VALVE_No036.DataTimeClosing.StartEdge := FALSE;
   VALVE_No036.DataTimeFeedback.StartTime := L#0;
   VALVE_No036.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No036.DataTimeReverse.StartTime := L#0;
   VALVE_No036.DataTimeReverse.StartEdge := FALSE;
   VALVE_No036.DataTimeOvertravel.StartTime := L#0;
   VALVE_No036.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No036.DataTimeExtFault.StartTime := L#0;
   VALVE_No036.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No036.DataTimeRestart.StartTime := L#0;
   VALVE_No036.DataTimeRestart.StartEdge := FALSE;
   VALVE_No036.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No036.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No036.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No036.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No036.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No036.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No036.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No036.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No036.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No036.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No036.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No036.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No036.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No036.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No036.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No036.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No036.PCONF.DlyTActFault := T#0MS;
   VALVE_No036.PCONF.DlyTOpening := T#0MS;
   VALVE_No036.PCONF.DlyTClosing := T#0MS;
   VALVE_No036.PCONF.DlyTFeedback := T#0MS;
   VALVE_No036.PCONF.DlyTReverse := T#0MS;
   VALVE_No036.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No036.PCONF.DlyTExtFault := T#0MS;
   VALVE_No036.PCONF.DlyTRestart := T#0MS;
   VALVE_No037.System := W#16#0;
   VALVE_No037.CmdOS := W#16#0;
   VALVE_No037.MirrorCmdOS := W#16#0;
   VALVE_No037.Test := W#16#0;
   VALVE_No037.AlarmOS := W#16#0;
   VALVE_No037.StatusOS := W#16#0;
   VALVE_No037.SysStatusOS := W#16#0;
   VALVE_No037.Status1 := W#16#0;
   VALVE_No037.Status2 := W#16#0;
   VALVE_No037.Status3 := B#16#0;
   VALVE_No037.InputEdges := B#16#0;
   VALVE_No037.AutoEdges := W#16#0;
   VALVE_No037.DataTimeActFault.StartTime := L#0;
   VALVE_No037.DataTimeActFault.StartEdge := FALSE;
   VALVE_No037.DataTimeOpening.StartTime := L#0;
   VALVE_No037.DataTimeOpening.StartEdge := FALSE;
   VALVE_No037.DataTimeClosing.StartTime := L#0;
   VALVE_No037.DataTimeClosing.StartEdge := FALSE;
   VALVE_No037.DataTimeFeedback.StartTime := L#0;
   VALVE_No037.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No037.DataTimeReverse.StartTime := L#0;
   VALVE_No037.DataTimeReverse.StartEdge := FALSE;
   VALVE_No037.DataTimeOvertravel.StartTime := L#0;
   VALVE_No037.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No037.DataTimeExtFault.StartTime := L#0;
   VALVE_No037.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No037.DataTimeRestart.StartTime := L#0;
   VALVE_No037.DataTimeRestart.StartEdge := FALSE;
   VALVE_No037.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No037.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No037.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No037.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No037.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No037.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No037.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No037.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No037.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No037.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No037.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No037.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No037.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No037.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No037.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No037.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No037.PCONF.DlyTActFault := T#0MS;
   VALVE_No037.PCONF.DlyTOpening := T#0MS;
   VALVE_No037.PCONF.DlyTClosing := T#0MS;
   VALVE_No037.PCONF.DlyTFeedback := T#0MS;
   VALVE_No037.PCONF.DlyTReverse := T#0MS;
   VALVE_No037.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No037.PCONF.DlyTExtFault := T#0MS;
   VALVE_No037.PCONF.DlyTRestart := T#0MS;
   VALVE_No038.System := W#16#0;
   VALVE_No038.CmdOS := W#16#0;
   VALVE_No038.MirrorCmdOS := W#16#0;
   VALVE_No038.Test := W#16#0;
   VALVE_No038.AlarmOS := W#16#0;
   VALVE_No038.StatusOS := W#16#0;
   VALVE_No038.SysStatusOS := W#16#0;
   VALVE_No038.Status1 := W#16#0;
   VALVE_No038.Status2 := W#16#0;
   VALVE_No038.Status3 := B#16#0;
   VALVE_No038.InputEdges := B#16#0;
   VALVE_No038.AutoEdges := W#16#0;
   VALVE_No038.DataTimeActFault.StartTime := L#0;
   VALVE_No038.DataTimeActFault.StartEdge := FALSE;
   VALVE_No038.DataTimeOpening.StartTime := L#0;
   VALVE_No038.DataTimeOpening.StartEdge := FALSE;
   VALVE_No038.DataTimeClosing.StartTime := L#0;
   VALVE_No038.DataTimeClosing.StartEdge := FALSE;
   VALVE_No038.DataTimeFeedback.StartTime := L#0;
   VALVE_No038.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No038.DataTimeReverse.StartTime := L#0;
   VALVE_No038.DataTimeReverse.StartEdge := FALSE;
   VALVE_No038.DataTimeOvertravel.StartTime := L#0;
   VALVE_No038.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No038.DataTimeExtFault.StartTime := L#0;
   VALVE_No038.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No038.DataTimeRestart.StartTime := L#0;
   VALVE_No038.DataTimeRestart.StartEdge := FALSE;
   VALVE_No038.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No038.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No038.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No038.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No038.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No038.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No038.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No038.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No038.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No038.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No038.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No038.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No038.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No038.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No038.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No038.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No038.PCONF.DlyTActFault := T#0MS;
   VALVE_No038.PCONF.DlyTOpening := T#0MS;
   VALVE_No038.PCONF.DlyTClosing := T#0MS;
   VALVE_No038.PCONF.DlyTFeedback := T#0MS;
   VALVE_No038.PCONF.DlyTReverse := T#0MS;
   VALVE_No038.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No038.PCONF.DlyTExtFault := T#0MS;
   VALVE_No038.PCONF.DlyTRestart := T#0MS;
   VALVE_No039.System := W#16#0;
   VALVE_No039.CmdOS := W#16#0;
   VALVE_No039.MirrorCmdOS := W#16#0;
   VALVE_No039.Test := W#16#0;
   VALVE_No039.AlarmOS := W#16#0;
   VALVE_No039.StatusOS := W#16#0;
   VALVE_No039.SysStatusOS := W#16#0;
   VALVE_No039.Status1 := W#16#0;
   VALVE_No039.Status2 := W#16#0;
   VALVE_No039.Status3 := B#16#0;
   VALVE_No039.InputEdges := B#16#0;
   VALVE_No039.AutoEdges := W#16#0;
   VALVE_No039.DataTimeActFault.StartTime := L#0;
   VALVE_No039.DataTimeActFault.StartEdge := FALSE;
   VALVE_No039.DataTimeOpening.StartTime := L#0;
   VALVE_No039.DataTimeOpening.StartEdge := FALSE;
   VALVE_No039.DataTimeClosing.StartTime := L#0;
   VALVE_No039.DataTimeClosing.StartEdge := FALSE;
   VALVE_No039.DataTimeFeedback.StartTime := L#0;
   VALVE_No039.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No039.DataTimeReverse.StartTime := L#0;
   VALVE_No039.DataTimeReverse.StartEdge := FALSE;
   VALVE_No039.DataTimeOvertravel.StartTime := L#0;
   VALVE_No039.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No039.DataTimeExtFault.StartTime := L#0;
   VALVE_No039.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No039.DataTimeRestart.StartTime := L#0;
   VALVE_No039.DataTimeRestart.StartEdge := FALSE;
   VALVE_No039.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No039.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No039.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No039.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No039.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No039.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No039.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No039.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No039.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No039.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No039.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No039.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No039.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No039.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No039.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No039.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No039.PCONF.DlyTActFault := T#0MS;
   VALVE_No039.PCONF.DlyTOpening := T#0MS;
   VALVE_No039.PCONF.DlyTClosing := T#0MS;
   VALVE_No039.PCONF.DlyTFeedback := T#0MS;
   VALVE_No039.PCONF.DlyTReverse := T#0MS;
   VALVE_No039.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No039.PCONF.DlyTExtFault := T#0MS;
   VALVE_No039.PCONF.DlyTRestart := T#0MS;
   VALVE_No040.System := W#16#0;
   VALVE_No040.CmdOS := W#16#0;
   VALVE_No040.MirrorCmdOS := W#16#0;
   VALVE_No040.Test := W#16#0;
   VALVE_No040.AlarmOS := W#16#0;
   VALVE_No040.StatusOS := W#16#0;
   VALVE_No040.SysStatusOS := W#16#0;
   VALVE_No040.Status1 := W#16#0;
   VALVE_No040.Status2 := W#16#0;
   VALVE_No040.Status3 := B#16#0;
   VALVE_No040.InputEdges := B#16#0;
   VALVE_No040.AutoEdges := W#16#0;
   VALVE_No040.DataTimeActFault.StartTime := L#0;
   VALVE_No040.DataTimeActFault.StartEdge := FALSE;
   VALVE_No040.DataTimeOpening.StartTime := L#0;
   VALVE_No040.DataTimeOpening.StartEdge := FALSE;
   VALVE_No040.DataTimeClosing.StartTime := L#0;
   VALVE_No040.DataTimeClosing.StartEdge := FALSE;
   VALVE_No040.DataTimeFeedback.StartTime := L#0;
   VALVE_No040.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No040.DataTimeReverse.StartTime := L#0;
   VALVE_No040.DataTimeReverse.StartEdge := FALSE;
   VALVE_No040.DataTimeOvertravel.StartTime := L#0;
   VALVE_No040.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No040.DataTimeExtFault.StartTime := L#0;
   VALVE_No040.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No040.DataTimeRestart.StartTime := L#0;
   VALVE_No040.DataTimeRestart.StartEdge := FALSE;
   VALVE_No040.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No040.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No040.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No040.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No040.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No040.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No040.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No040.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No040.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No040.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No040.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No040.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No040.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No040.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No040.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No040.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No040.PCONF.DlyTActFault := T#0MS;
   VALVE_No040.PCONF.DlyTOpening := T#0MS;
   VALVE_No040.PCONF.DlyTClosing := T#0MS;
   VALVE_No040.PCONF.DlyTFeedback := T#0MS;
   VALVE_No040.PCONF.DlyTReverse := T#0MS;
   VALVE_No040.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No040.PCONF.DlyTExtFault := T#0MS;
   VALVE_No040.PCONF.DlyTRestart := T#0MS;
   VALVE_No041.System := W#16#0;
   VALVE_No041.CmdOS := W#16#0;
   VALVE_No041.MirrorCmdOS := W#16#0;
   VALVE_No041.Test := W#16#0;
   VALVE_No041.AlarmOS := W#16#0;
   VALVE_No041.StatusOS := W#16#0;
   VALVE_No041.SysStatusOS := W#16#0;
   VALVE_No041.Status1 := W#16#0;
   VALVE_No041.Status2 := W#16#0;
   VALVE_No041.Status3 := B#16#0;
   VALVE_No041.InputEdges := B#16#0;
   VALVE_No041.AutoEdges := W#16#0;
   VALVE_No041.DataTimeActFault.StartTime := L#0;
   VALVE_No041.DataTimeActFault.StartEdge := FALSE;
   VALVE_No041.DataTimeOpening.StartTime := L#0;
   VALVE_No041.DataTimeOpening.StartEdge := FALSE;
   VALVE_No041.DataTimeClosing.StartTime := L#0;
   VALVE_No041.DataTimeClosing.StartEdge := FALSE;
   VALVE_No041.DataTimeFeedback.StartTime := L#0;
   VALVE_No041.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No041.DataTimeReverse.StartTime := L#0;
   VALVE_No041.DataTimeReverse.StartEdge := FALSE;
   VALVE_No041.DataTimeOvertravel.StartTime := L#0;
   VALVE_No041.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No041.DataTimeExtFault.StartTime := L#0;
   VALVE_No041.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No041.DataTimeRestart.StartTime := L#0;
   VALVE_No041.DataTimeRestart.StartEdge := FALSE;
   VALVE_No041.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No041.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No041.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No041.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No041.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No041.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No041.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No041.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No041.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No041.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No041.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No041.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No041.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No041.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No041.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No041.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No041.PCONF.DlyTActFault := T#0MS;
   VALVE_No041.PCONF.DlyTOpening := T#0MS;
   VALVE_No041.PCONF.DlyTClosing := T#0MS;
   VALVE_No041.PCONF.DlyTFeedback := T#0MS;
   VALVE_No041.PCONF.DlyTReverse := T#0MS;
   VALVE_No041.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No041.PCONF.DlyTExtFault := T#0MS;
   VALVE_No041.PCONF.DlyTRestart := T#0MS;
   VALVE_No042.System := W#16#0;
   VALVE_No042.CmdOS := W#16#0;
   VALVE_No042.MirrorCmdOS := W#16#0;
   VALVE_No042.Test := W#16#0;
   VALVE_No042.AlarmOS := W#16#0;
   VALVE_No042.StatusOS := W#16#0;
   VALVE_No042.SysStatusOS := W#16#0;
   VALVE_No042.Status1 := W#16#0;
   VALVE_No042.Status2 := W#16#0;
   VALVE_No042.Status3 := B#16#0;
   VALVE_No042.InputEdges := B#16#0;
   VALVE_No042.AutoEdges := W#16#0;
   VALVE_No042.DataTimeActFault.StartTime := L#0;
   VALVE_No042.DataTimeActFault.StartEdge := FALSE;
   VALVE_No042.DataTimeOpening.StartTime := L#0;
   VALVE_No042.DataTimeOpening.StartEdge := FALSE;
   VALVE_No042.DataTimeClosing.StartTime := L#0;
   VALVE_No042.DataTimeClosing.StartEdge := FALSE;
   VALVE_No042.DataTimeFeedback.StartTime := L#0;
   VALVE_No042.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No042.DataTimeReverse.StartTime := L#0;
   VALVE_No042.DataTimeReverse.StartEdge := FALSE;
   VALVE_No042.DataTimeOvertravel.StartTime := L#0;
   VALVE_No042.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No042.DataTimeExtFault.StartTime := L#0;
   VALVE_No042.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No042.DataTimeRestart.StartTime := L#0;
   VALVE_No042.DataTimeRestart.StartEdge := FALSE;
   VALVE_No042.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No042.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No042.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No042.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No042.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No042.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No042.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No042.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No042.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No042.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No042.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No042.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No042.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No042.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No042.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No042.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No042.PCONF.DlyTActFault := T#0MS;
   VALVE_No042.PCONF.DlyTOpening := T#0MS;
   VALVE_No042.PCONF.DlyTClosing := T#0MS;
   VALVE_No042.PCONF.DlyTFeedback := T#0MS;
   VALVE_No042.PCONF.DlyTReverse := T#0MS;
   VALVE_No042.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No042.PCONF.DlyTExtFault := T#0MS;
   VALVE_No042.PCONF.DlyTRestart := T#0MS;
   VALVE_No043.System := W#16#0;
   VALVE_No043.CmdOS := W#16#0;
   VALVE_No043.MirrorCmdOS := W#16#0;
   VALVE_No043.Test := W#16#0;
   VALVE_No043.AlarmOS := W#16#0;
   VALVE_No043.StatusOS := W#16#0;
   VALVE_No043.SysStatusOS := W#16#0;
   VALVE_No043.Status1 := W#16#0;
   VALVE_No043.Status2 := W#16#0;
   VALVE_No043.Status3 := B#16#0;
   VALVE_No043.InputEdges := B#16#0;
   VALVE_No043.AutoEdges := W#16#0;
   VALVE_No043.DataTimeActFault.StartTime := L#0;
   VALVE_No043.DataTimeActFault.StartEdge := FALSE;
   VALVE_No043.DataTimeOpening.StartTime := L#0;
   VALVE_No043.DataTimeOpening.StartEdge := FALSE;
   VALVE_No043.DataTimeClosing.StartTime := L#0;
   VALVE_No043.DataTimeClosing.StartEdge := FALSE;
   VALVE_No043.DataTimeFeedback.StartTime := L#0;
   VALVE_No043.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No043.DataTimeReverse.StartTime := L#0;
   VALVE_No043.DataTimeReverse.StartEdge := FALSE;
   VALVE_No043.DataTimeOvertravel.StartTime := L#0;
   VALVE_No043.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No043.DataTimeExtFault.StartTime := L#0;
   VALVE_No043.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No043.DataTimeRestart.StartTime := L#0;
   VALVE_No043.DataTimeRestart.StartEdge := FALSE;
   VALVE_No043.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No043.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No043.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No043.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No043.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No043.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No043.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No043.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No043.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No043.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No043.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No043.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No043.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No043.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No043.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No043.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No043.PCONF.DlyTActFault := T#0MS;
   VALVE_No043.PCONF.DlyTOpening := T#0MS;
   VALVE_No043.PCONF.DlyTClosing := T#0MS;
   VALVE_No043.PCONF.DlyTFeedback := T#0MS;
   VALVE_No043.PCONF.DlyTReverse := T#0MS;
   VALVE_No043.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No043.PCONF.DlyTExtFault := T#0MS;
   VALVE_No043.PCONF.DlyTRestart := T#0MS;
   VALVE_No044.System := W#16#0;
   VALVE_No044.CmdOS := W#16#0;
   VALVE_No044.MirrorCmdOS := W#16#0;
   VALVE_No044.Test := W#16#0;
   VALVE_No044.AlarmOS := W#16#0;
   VALVE_No044.StatusOS := W#16#0;
   VALVE_No044.SysStatusOS := W#16#0;
   VALVE_No044.Status1 := W#16#0;
   VALVE_No044.Status2 := W#16#0;
   VALVE_No044.Status3 := B#16#0;
   VALVE_No044.InputEdges := B#16#0;
   VALVE_No044.AutoEdges := W#16#0;
   VALVE_No044.DataTimeActFault.StartTime := L#0;
   VALVE_No044.DataTimeActFault.StartEdge := FALSE;
   VALVE_No044.DataTimeOpening.StartTime := L#0;
   VALVE_No044.DataTimeOpening.StartEdge := FALSE;
   VALVE_No044.DataTimeClosing.StartTime := L#0;
   VALVE_No044.DataTimeClosing.StartEdge := FALSE;
   VALVE_No044.DataTimeFeedback.StartTime := L#0;
   VALVE_No044.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No044.DataTimeReverse.StartTime := L#0;
   VALVE_No044.DataTimeReverse.StartEdge := FALSE;
   VALVE_No044.DataTimeOvertravel.StartTime := L#0;
   VALVE_No044.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No044.DataTimeExtFault.StartTime := L#0;
   VALVE_No044.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No044.DataTimeRestart.StartTime := L#0;
   VALVE_No044.DataTimeRestart.StartEdge := FALSE;
   VALVE_No044.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No044.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No044.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No044.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No044.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No044.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No044.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No044.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No044.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No044.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No044.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No044.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No044.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No044.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No044.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No044.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No044.PCONF.DlyTActFault := T#0MS;
   VALVE_No044.PCONF.DlyTOpening := T#0MS;
   VALVE_No044.PCONF.DlyTClosing := T#0MS;
   VALVE_No044.PCONF.DlyTFeedback := T#0MS;
   VALVE_No044.PCONF.DlyTReverse := T#0MS;
   VALVE_No044.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No044.PCONF.DlyTExtFault := T#0MS;
   VALVE_No044.PCONF.DlyTRestart := T#0MS;
   VALVE_No045.System := W#16#0;
   VALVE_No045.CmdOS := W#16#0;
   VALVE_No045.MirrorCmdOS := W#16#0;
   VALVE_No045.Test := W#16#0;
   VALVE_No045.AlarmOS := W#16#0;
   VALVE_No045.StatusOS := W#16#0;
   VALVE_No045.SysStatusOS := W#16#0;
   VALVE_No045.Status1 := W#16#0;
   VALVE_No045.Status2 := W#16#0;
   VALVE_No045.Status3 := B#16#0;
   VALVE_No045.InputEdges := B#16#0;
   VALVE_No045.AutoEdges := W#16#0;
   VALVE_No045.DataTimeActFault.StartTime := L#0;
   VALVE_No045.DataTimeActFault.StartEdge := FALSE;
   VALVE_No045.DataTimeOpening.StartTime := L#0;
   VALVE_No045.DataTimeOpening.StartEdge := FALSE;
   VALVE_No045.DataTimeClosing.StartTime := L#0;
   VALVE_No045.DataTimeClosing.StartEdge := FALSE;
   VALVE_No045.DataTimeFeedback.StartTime := L#0;
   VALVE_No045.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No045.DataTimeReverse.StartTime := L#0;
   VALVE_No045.DataTimeReverse.StartEdge := FALSE;
   VALVE_No045.DataTimeOvertravel.StartTime := L#0;
   VALVE_No045.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No045.DataTimeExtFault.StartTime := L#0;
   VALVE_No045.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No045.DataTimeRestart.StartTime := L#0;
   VALVE_No045.DataTimeRestart.StartEdge := FALSE;
   VALVE_No045.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No045.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No045.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No045.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No045.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No045.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No045.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No045.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No045.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No045.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No045.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No045.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No045.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No045.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No045.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No045.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No045.PCONF.DlyTActFault := T#0MS;
   VALVE_No045.PCONF.DlyTOpening := T#0MS;
   VALVE_No045.PCONF.DlyTClosing := T#0MS;
   VALVE_No045.PCONF.DlyTFeedback := T#0MS;
   VALVE_No045.PCONF.DlyTReverse := T#0MS;
   VALVE_No045.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No045.PCONF.DlyTExtFault := T#0MS;
   VALVE_No045.PCONF.DlyTRestart := T#0MS;
   VALVE_No046.System := W#16#0;
   VALVE_No046.CmdOS := W#16#0;
   VALVE_No046.MirrorCmdOS := W#16#0;
   VALVE_No046.Test := W#16#0;
   VALVE_No046.AlarmOS := W#16#0;
   VALVE_No046.StatusOS := W#16#0;
   VALVE_No046.SysStatusOS := W#16#0;
   VALVE_No046.Status1 := W#16#0;
   VALVE_No046.Status2 := W#16#0;
   VALVE_No046.Status3 := B#16#0;
   VALVE_No046.InputEdges := B#16#0;
   VALVE_No046.AutoEdges := W#16#0;
   VALVE_No046.DataTimeActFault.StartTime := L#0;
   VALVE_No046.DataTimeActFault.StartEdge := FALSE;
   VALVE_No046.DataTimeOpening.StartTime := L#0;
   VALVE_No046.DataTimeOpening.StartEdge := FALSE;
   VALVE_No046.DataTimeClosing.StartTime := L#0;
   VALVE_No046.DataTimeClosing.StartEdge := FALSE;
   VALVE_No046.DataTimeFeedback.StartTime := L#0;
   VALVE_No046.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No046.DataTimeReverse.StartTime := L#0;
   VALVE_No046.DataTimeReverse.StartEdge := FALSE;
   VALVE_No046.DataTimeOvertravel.StartTime := L#0;
   VALVE_No046.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No046.DataTimeExtFault.StartTime := L#0;
   VALVE_No046.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No046.DataTimeRestart.StartTime := L#0;
   VALVE_No046.DataTimeRestart.StartEdge := FALSE;
   VALVE_No046.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No046.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No046.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No046.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No046.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No046.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No046.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No046.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No046.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No046.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No046.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No046.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No046.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No046.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No046.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No046.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No046.PCONF.DlyTActFault := T#0MS;
   VALVE_No046.PCONF.DlyTOpening := T#0MS;
   VALVE_No046.PCONF.DlyTClosing := T#0MS;
   VALVE_No046.PCONF.DlyTFeedback := T#0MS;
   VALVE_No046.PCONF.DlyTReverse := T#0MS;
   VALVE_No046.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No046.PCONF.DlyTExtFault := T#0MS;
   VALVE_No046.PCONF.DlyTRestart := T#0MS;
   VALVE_No047.System := W#16#0;
   VALVE_No047.CmdOS := W#16#0;
   VALVE_No047.MirrorCmdOS := W#16#0;
   VALVE_No047.Test := W#16#0;
   VALVE_No047.AlarmOS := W#16#0;
   VALVE_No047.StatusOS := W#16#0;
   VALVE_No047.SysStatusOS := W#16#0;
   VALVE_No047.Status1 := W#16#0;
   VALVE_No047.Status2 := W#16#0;
   VALVE_No047.Status3 := B#16#0;
   VALVE_No047.InputEdges := B#16#0;
   VALVE_No047.AutoEdges := W#16#0;
   VALVE_No047.DataTimeActFault.StartTime := L#0;
   VALVE_No047.DataTimeActFault.StartEdge := FALSE;
   VALVE_No047.DataTimeOpening.StartTime := L#0;
   VALVE_No047.DataTimeOpening.StartEdge := FALSE;
   VALVE_No047.DataTimeClosing.StartTime := L#0;
   VALVE_No047.DataTimeClosing.StartEdge := FALSE;
   VALVE_No047.DataTimeFeedback.StartTime := L#0;
   VALVE_No047.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No047.DataTimeReverse.StartTime := L#0;
   VALVE_No047.DataTimeReverse.StartEdge := FALSE;
   VALVE_No047.DataTimeOvertravel.StartTime := L#0;
   VALVE_No047.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No047.DataTimeExtFault.StartTime := L#0;
   VALVE_No047.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No047.DataTimeRestart.StartTime := L#0;
   VALVE_No047.DataTimeRestart.StartEdge := FALSE;
   VALVE_No047.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No047.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No047.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No047.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No047.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No047.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No047.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No047.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No047.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No047.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No047.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No047.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No047.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No047.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No047.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No047.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No047.PCONF.DlyTActFault := T#0MS;
   VALVE_No047.PCONF.DlyTOpening := T#0MS;
   VALVE_No047.PCONF.DlyTClosing := T#0MS;
   VALVE_No047.PCONF.DlyTFeedback := T#0MS;
   VALVE_No047.PCONF.DlyTReverse := T#0MS;
   VALVE_No047.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No047.PCONF.DlyTExtFault := T#0MS;
   VALVE_No047.PCONF.DlyTRestart := T#0MS;
   VALVE_No048.System := W#16#0;
   VALVE_No048.CmdOS := W#16#0;
   VALVE_No048.MirrorCmdOS := W#16#0;
   VALVE_No048.Test := W#16#0;
   VALVE_No048.AlarmOS := W#16#0;
   VALVE_No048.StatusOS := W#16#0;
   VALVE_No048.SysStatusOS := W#16#0;
   VALVE_No048.Status1 := W#16#0;
   VALVE_No048.Status2 := W#16#0;
   VALVE_No048.Status3 := B#16#0;
   VALVE_No048.InputEdges := B#16#0;
   VALVE_No048.AutoEdges := W#16#0;
   VALVE_No048.DataTimeActFault.StartTime := L#0;
   VALVE_No048.DataTimeActFault.StartEdge := FALSE;
   VALVE_No048.DataTimeOpening.StartTime := L#0;
   VALVE_No048.DataTimeOpening.StartEdge := FALSE;
   VALVE_No048.DataTimeClosing.StartTime := L#0;
   VALVE_No048.DataTimeClosing.StartEdge := FALSE;
   VALVE_No048.DataTimeFeedback.StartTime := L#0;
   VALVE_No048.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No048.DataTimeReverse.StartTime := L#0;
   VALVE_No048.DataTimeReverse.StartEdge := FALSE;
   VALVE_No048.DataTimeOvertravel.StartTime := L#0;
   VALVE_No048.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No048.DataTimeExtFault.StartTime := L#0;
   VALVE_No048.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No048.DataTimeRestart.StartTime := L#0;
   VALVE_No048.DataTimeRestart.StartEdge := FALSE;
   VALVE_No048.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No048.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No048.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No048.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No048.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No048.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No048.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No048.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No048.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No048.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No048.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No048.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No048.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No048.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No048.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No048.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No048.PCONF.DlyTActFault := T#0MS;
   VALVE_No048.PCONF.DlyTOpening := T#0MS;
   VALVE_No048.PCONF.DlyTClosing := T#0MS;
   VALVE_No048.PCONF.DlyTFeedback := T#0MS;
   VALVE_No048.PCONF.DlyTReverse := T#0MS;
   VALVE_No048.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No048.PCONF.DlyTExtFault := T#0MS;
   VALVE_No048.PCONF.DlyTRestart := T#0MS;
   VALVE_No049.System := W#16#0;
   VALVE_No049.CmdOS := W#16#0;
   VALVE_No049.MirrorCmdOS := W#16#0;
   VALVE_No049.Test := W#16#0;
   VALVE_No049.AlarmOS := W#16#0;
   VALVE_No049.StatusOS := W#16#0;
   VALVE_No049.SysStatusOS := W#16#0;
   VALVE_No049.Status1 := W#16#0;
   VALVE_No049.Status2 := W#16#0;
   VALVE_No049.Status3 := B#16#0;
   VALVE_No049.InputEdges := B#16#0;
   VALVE_No049.AutoEdges := W#16#0;
   VALVE_No049.DataTimeActFault.StartTime := L#0;
   VALVE_No049.DataTimeActFault.StartEdge := FALSE;
   VALVE_No049.DataTimeOpening.StartTime := L#0;
   VALVE_No049.DataTimeOpening.StartEdge := FALSE;
   VALVE_No049.DataTimeClosing.StartTime := L#0;
   VALVE_No049.DataTimeClosing.StartEdge := FALSE;
   VALVE_No049.DataTimeFeedback.StartTime := L#0;
   VALVE_No049.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No049.DataTimeReverse.StartTime := L#0;
   VALVE_No049.DataTimeReverse.StartEdge := FALSE;
   VALVE_No049.DataTimeOvertravel.StartTime := L#0;
   VALVE_No049.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No049.DataTimeExtFault.StartTime := L#0;
   VALVE_No049.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No049.DataTimeRestart.StartTime := L#0;
   VALVE_No049.DataTimeRestart.StartEdge := FALSE;
   VALVE_No049.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No049.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No049.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No049.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No049.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No049.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No049.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No049.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No049.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No049.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No049.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No049.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No049.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No049.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No049.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No049.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No049.PCONF.DlyTActFault := T#0MS;
   VALVE_No049.PCONF.DlyTOpening := T#0MS;
   VALVE_No049.PCONF.DlyTClosing := T#0MS;
   VALVE_No049.PCONF.DlyTFeedback := T#0MS;
   VALVE_No049.PCONF.DlyTReverse := T#0MS;
   VALVE_No049.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No049.PCONF.DlyTExtFault := T#0MS;
   VALVE_No049.PCONF.DlyTRestart := T#0MS;
   VALVE_No050.System := W#16#0;
   VALVE_No050.CmdOS := W#16#0;
   VALVE_No050.MirrorCmdOS := W#16#0;
   VALVE_No050.Test := W#16#0;
   VALVE_No050.AlarmOS := W#16#0;
   VALVE_No050.StatusOS := W#16#0;
   VALVE_No050.SysStatusOS := W#16#0;
   VALVE_No050.Status1 := W#16#0;
   VALVE_No050.Status2 := W#16#0;
   VALVE_No050.Status3 := B#16#0;
   VALVE_No050.InputEdges := B#16#0;
   VALVE_No050.AutoEdges := W#16#0;
   VALVE_No050.DataTimeActFault.StartTime := L#0;
   VALVE_No050.DataTimeActFault.StartEdge := FALSE;
   VALVE_No050.DataTimeOpening.StartTime := L#0;
   VALVE_No050.DataTimeOpening.StartEdge := FALSE;
   VALVE_No050.DataTimeClosing.StartTime := L#0;
   VALVE_No050.DataTimeClosing.StartEdge := FALSE;
   VALVE_No050.DataTimeFeedback.StartTime := L#0;
   VALVE_No050.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No050.DataTimeReverse.StartTime := L#0;
   VALVE_No050.DataTimeReverse.StartEdge := FALSE;
   VALVE_No050.DataTimeOvertravel.StartTime := L#0;
   VALVE_No050.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No050.DataTimeExtFault.StartTime := L#0;
   VALVE_No050.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No050.DataTimeRestart.StartTime := L#0;
   VALVE_No050.DataTimeRestart.StartEdge := FALSE;
   VALVE_No050.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No050.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No050.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No050.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No050.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No050.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No050.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No050.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No050.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No050.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No050.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No050.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No050.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No050.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No050.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No050.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No050.PCONF.DlyTActFault := T#0MS;
   VALVE_No050.PCONF.DlyTOpening := T#0MS;
   VALVE_No050.PCONF.DlyTClosing := T#0MS;
   VALVE_No050.PCONF.DlyTFeedback := T#0MS;
   VALVE_No050.PCONF.DlyTReverse := T#0MS;
   VALVE_No050.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No050.PCONF.DlyTExtFault := T#0MS;
   VALVE_No050.PCONF.DlyTRestart := T#0MS;
   VALVE_No051.System := W#16#0;
   VALVE_No051.CmdOS := W#16#0;
   VALVE_No051.MirrorCmdOS := W#16#0;
   VALVE_No051.Test := W#16#0;
   VALVE_No051.AlarmOS := W#16#0;
   VALVE_No051.StatusOS := W#16#0;
   VALVE_No051.SysStatusOS := W#16#0;
   VALVE_No051.Status1 := W#16#0;
   VALVE_No051.Status2 := W#16#0;
   VALVE_No051.Status3 := B#16#0;
   VALVE_No051.InputEdges := B#16#0;
   VALVE_No051.AutoEdges := W#16#0;
   VALVE_No051.DataTimeActFault.StartTime := L#0;
   VALVE_No051.DataTimeActFault.StartEdge := FALSE;
   VALVE_No051.DataTimeOpening.StartTime := L#0;
   VALVE_No051.DataTimeOpening.StartEdge := FALSE;
   VALVE_No051.DataTimeClosing.StartTime := L#0;
   VALVE_No051.DataTimeClosing.StartEdge := FALSE;
   VALVE_No051.DataTimeFeedback.StartTime := L#0;
   VALVE_No051.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No051.DataTimeReverse.StartTime := L#0;
   VALVE_No051.DataTimeReverse.StartEdge := FALSE;
   VALVE_No051.DataTimeOvertravel.StartTime := L#0;
   VALVE_No051.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No051.DataTimeExtFault.StartTime := L#0;
   VALVE_No051.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No051.DataTimeRestart.StartTime := L#0;
   VALVE_No051.DataTimeRestart.StartEdge := FALSE;
   VALVE_No051.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No051.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No051.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No051.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No051.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No051.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No051.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No051.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No051.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No051.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No051.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No051.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No051.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No051.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No051.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No051.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No051.PCONF.DlyTActFault := T#0MS;
   VALVE_No051.PCONF.DlyTOpening := T#0MS;
   VALVE_No051.PCONF.DlyTClosing := T#0MS;
   VALVE_No051.PCONF.DlyTFeedback := T#0MS;
   VALVE_No051.PCONF.DlyTReverse := T#0MS;
   VALVE_No051.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No051.PCONF.DlyTExtFault := T#0MS;
   VALVE_No051.PCONF.DlyTRestart := T#0MS;
   VALVE_No052.System := W#16#0;
   VALVE_No052.CmdOS := W#16#0;
   VALVE_No052.MirrorCmdOS := W#16#0;
   VALVE_No052.Test := W#16#0;
   VALVE_No052.AlarmOS := W#16#0;
   VALVE_No052.StatusOS := W#16#0;
   VALVE_No052.SysStatusOS := W#16#0;
   VALVE_No052.Status1 := W#16#0;
   VALVE_No052.Status2 := W#16#0;
   VALVE_No052.Status3 := B#16#0;
   VALVE_No052.InputEdges := B#16#0;
   VALVE_No052.AutoEdges := W#16#0;
   VALVE_No052.DataTimeActFault.StartTime := L#0;
   VALVE_No052.DataTimeActFault.StartEdge := FALSE;
   VALVE_No052.DataTimeOpening.StartTime := L#0;
   VALVE_No052.DataTimeOpening.StartEdge := FALSE;
   VALVE_No052.DataTimeClosing.StartTime := L#0;
   VALVE_No052.DataTimeClosing.StartEdge := FALSE;
   VALVE_No052.DataTimeFeedback.StartTime := L#0;
   VALVE_No052.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No052.DataTimeReverse.StartTime := L#0;
   VALVE_No052.DataTimeReverse.StartEdge := FALSE;
   VALVE_No052.DataTimeOvertravel.StartTime := L#0;
   VALVE_No052.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No052.DataTimeExtFault.StartTime := L#0;
   VALVE_No052.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No052.DataTimeRestart.StartTime := L#0;
   VALVE_No052.DataTimeRestart.StartEdge := FALSE;
   VALVE_No052.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No052.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No052.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No052.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No052.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No052.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No052.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No052.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No052.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No052.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No052.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No052.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No052.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No052.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No052.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No052.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No052.PCONF.DlyTActFault := T#0MS;
   VALVE_No052.PCONF.DlyTOpening := T#0MS;
   VALVE_No052.PCONF.DlyTClosing := T#0MS;
   VALVE_No052.PCONF.DlyTFeedback := T#0MS;
   VALVE_No052.PCONF.DlyTReverse := T#0MS;
   VALVE_No052.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No052.PCONF.DlyTExtFault := T#0MS;
   VALVE_No052.PCONF.DlyTRestart := T#0MS;
   VALVE_No053.System := W#16#0;
   VALVE_No053.CmdOS := W#16#0;
   VALVE_No053.MirrorCmdOS := W#16#0;
   VALVE_No053.Test := W#16#0;
   VALVE_No053.AlarmOS := W#16#0;
   VALVE_No053.StatusOS := W#16#0;
   VALVE_No053.SysStatusOS := W#16#0;
   VALVE_No053.Status1 := W#16#0;
   VALVE_No053.Status2 := W#16#0;
   VALVE_No053.Status3 := B#16#0;
   VALVE_No053.InputEdges := B#16#0;
   VALVE_No053.AutoEdges := W#16#0;
   VALVE_No053.DataTimeActFault.StartTime := L#0;
   VALVE_No053.DataTimeActFault.StartEdge := FALSE;
   VALVE_No053.DataTimeOpening.StartTime := L#0;
   VALVE_No053.DataTimeOpening.StartEdge := FALSE;
   VALVE_No053.DataTimeClosing.StartTime := L#0;
   VALVE_No053.DataTimeClosing.StartEdge := FALSE;
   VALVE_No053.DataTimeFeedback.StartTime := L#0;
   VALVE_No053.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No053.DataTimeReverse.StartTime := L#0;
   VALVE_No053.DataTimeReverse.StartEdge := FALSE;
   VALVE_No053.DataTimeOvertravel.StartTime := L#0;
   VALVE_No053.DataTimeOvertravel.StartEdge := FALSE;
   VALVE_No053.DataTimeExtFault.StartTime := L#0;
   VALVE_No053.DataTimeExtFault.StartEdge := FALSE;
   VALVE_No053.DataTimeRestart.StartTime := L#0;
   VALVE_No053.DataTimeRestart.StartEdge := FALSE;
   VALVE_No053.PCONF.Modeswitches.M0_SingleActingValve := FALSE;
   VALVE_No053.PCONF.Modeswitches.M1_ResetMode := FALSE;
   VALVE_No053.PCONF.Modeswitches.M2_OperationMode := FALSE;
   VALVE_No053.PCONF.Modeswitches.M3_Status := FALSE;
   VALVE_No053.PCONF.Modeswitches.M4_LockInput := FALSE;
   VALVE_No053.PCONF.Modeswitches.M5_ESO := FALSE;
   VALVE_No053.PCONF.Modeswitches.M6_ReverseTime := FALSE;
   VALVE_No053.PCONF.Modeswitches.M7_OvertravelTime := FALSE;
   VALVE_No053.PCONF.Modeswitches.M8_Spare := FALSE;
   VALVE_No053.PCONF.Modeswitches.M9_OpenAfterBlackout := FALSE;
   VALVE_No053.PCONF.Modeswitches.M10_ExtFaultNC := FALSE;
   VALVE_No053.PCONF.Modeswitches.M11_Spare := FALSE;
   VALVE_No053.PCONF.Modeswitches.M12_Spare := FALSE;
   VALVE_No053.PCONF.Modeswitches.M13_LocalAutoMode := FALSE;
   VALVE_No053.PCONF.Modeswitches.M14_Spare := FALSE;
   VALVE_No053.PCONF.Modeswitches.M15_Test := FALSE;
   VALVE_No053.PCONF.DlyTActFault := T#0MS;
   VALVE_No053.PCONF.DlyTOpening := T#0MS;
   VALVE_No053.PCONF.DlyTClosing := T#0MS;
   VALVE_No053.PCONF.DlyTFeedback := T#0MS;
   VALVE_No053.PCONF.DlyTReverse := T#0MS;
   VALVE_No053.PCONF.DlyTOvertravel := T#0MS;
   VALVE_No053.PCONF.DlyTExtFault := T#0MS;
   VALVE_No053.PCONF.DlyTRestart := T#0MS;
   VALVE_No054.System := W#16#0;
   VALVE_No054.CmdOS := W#16#0;
   VALVE_No054.MirrorCmdOS := W#16#0;
   VALVE_No054.Test := W#16#0;
   VALVE_No054.AlarmOS := W#16#0;
   VALVE_No054.StatusOS := W#16#0;
   VALVE_No054.SysStatusOS := W#16#0;
   VALVE_No054.Status1 := W#16#0;
   VALVE_No054.Status2 := W#16#0;
   VALVE_No054.Status3 := B#16#0;
   VALVE_No054.InputEdges := B#16#0;
   VALVE_No054.AutoEdges := W#16#0;
   VALVE_No054.DataTimeActFault.StartTime := L#0;
   VALVE_No054.DataTimeActFault.StartEdge := FALSE;
   VALVE_No054.DataTimeOpening.StartTime := L#0;
   VALVE_No054.DataTimeOpening.StartEdge := FALSE;
   VALVE_No054.DataTimeClosing.StartTime := L#0;
   VALVE_No054.DataTimeClosing.StartEdge := FALSE;
   VALVE_No054.DataTimeFeedback.StartTime := L#0;
   VALVE_No054.DataTimeFeedback.StartEdge := FALSE;
   VALVE_No054.DataTimeReverse.StartT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