DATA_BLOCK "IMAC_MOTOR1_RECORD"
TITLE =  MOTOR1_RECORD
AUTHOR : HottendU
FAMILY : IMAC
VERSION : 0.2


  STRUCT
   MOTOR1_No001 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 001
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL  := TRUE;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL  := TRUE;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL  := TRUE;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL  := TRUE;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME  := T#5S;	//Setpoint external fault delay
     DlyTFeedback : TIME  := T#10S;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME  := T#20S;	//Setpoint start action delay
     DlyTAutoAl : TIME  := T#15S;	//Setpoint auto alarm delay
     DlyTRestart : TIME  := T#1M;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME  := T#10S;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No002 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 002
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL  := TRUE;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL  := TRUE;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL  := TRUE;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME  := T#5S;	//Setpoint external fault delay
     DlyTFeedback : TIME  := T#10S;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME  := T#20S;	//Setpoint start action delay
     DlyTAutoAl : TIME  := T#15S;	//Setpoint auto alarm delay
     DlyTRestart : TIME  := T#1M;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME  := T#10S;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No003 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 003
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL  := TRUE;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL  := TRUE;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL  := TRUE;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME  := T#5S;	//Setpoint external fault delay
     DlyTFeedback : TIME  := T#10S;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME  := T#20S;	//Setpoint start action delay
     DlyTAutoAl : TIME  := T#15S;	//Setpoint auto alarm delay
     DlyTRestart : TIME  := T#1M;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME  := T#10S;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No004 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 004
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL  := TRUE;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL  := TRUE;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL  := TRUE;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME  := T#5S;	//Setpoint external fault delay
     DlyTFeedback : TIME  := T#10S;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME  := T#20S;	//Setpoint start action delay
     DlyTAutoAl : TIME  := T#15S;	//Setpoint auto alarm delay
     DlyTRestart : TIME  := T#1M;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME  := T#10S;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No005 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 005
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL  := TRUE;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL  := TRUE;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL  := TRUE;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME  := T#5S;	//Setpoint external fault delay
     DlyTFeedback : TIME  := T#10S;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME  := T#20S;	//Setpoint start action delay
     DlyTAutoAl : TIME  := T#15S;	//Setpoint auto alarm delay
     DlyTRestart : TIME  := T#1M;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME  := T#10S;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No006 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 006
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL  := TRUE;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL  := TRUE;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL  := TRUE;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME  := T#5S;	//Setpoint external fault delay
     DlyTFeedback : TIME  := T#10S;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME  := T#20S;	//Setpoint start action delay
     DlyTAutoAl : TIME  := T#15S;	//Setpoint auto alarm delay
     DlyTRestart : TIME  := T#1M;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME  := T#10S;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No007 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 007
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL ;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No008 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 008
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL ;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No009 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 009
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL ;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No010 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 010
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL ;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No011 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 011
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No012 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 012
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No013 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 013
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No014 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 014
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No015 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 015
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No016 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 016
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No017 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 017
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No018 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 018
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No0119 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 019
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No020 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 020
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No021 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 021
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No022 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 022
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No023 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 023
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No024 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 024
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No025 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 025
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No026 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 026
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No027 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 027
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No028 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 028
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No029 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 029
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No030 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 030
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No031 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 031
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No032 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 032
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No033 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 033
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No034 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 034
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No035 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 035
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No036 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 036
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No037 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 037
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No038 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 038
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No039 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 039
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No040 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 040
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No041 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 041
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No042 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 042
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No043 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 043
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No044 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 044
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No045 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 045
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No046 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 046
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No047 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 047
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No048 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 048
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No049 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 049
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
   MOTOR1_No050 : STRUCT
    System : WORD ;
    CmdOS : WORD ;
    MirrorCmdOS : WORD ;
    Test : WORD ;
    AlarmOS : WORD ;
    StatusOS : WORD ;
    SysStatusOS : WORD ;
    Status1 : WORD ;
    Status2 : WORD ;
    InputEdges : WORD ;
    AutoEdges : WORD ;
    DataTimeCmd : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeBlackout : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeExtFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeFeedback : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStrtActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeAutoAl : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeRestart : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    DataTimeStpActFault : STRUCT
     StartTime : DINT ;
     StartEdge : BOOL ;
    END_STRUCT ;
    PCONF : STRUCT 	//// PCONF MOTOR1 - Instance 050
     Modeswitches : STRUCT
      DlyAFaultStop : BOOL ;	//    Modeswitch Delayed Auto Fault with Stop
      sw01 : BOOL ;	//
      ExtFaultNC : BOOL ;	//    Modeswitch External Fault NC: FALSE=Normally Open, TRUE=Normally Closed
      sw03 : BOOL ;	//
      sw04 : BOOL ;	//
      sw05 : BOOL ;	//
      sw06 : BOOL ;	//
      sw07 : BOOL ;	//
      ConstOutput : BOOL  := TRUE;	//    Modeswitch Constant Output (FALSE='Double Acting', TRUE= 'Single Acting')
      ExtraAutomode : BOOL ;	//    Extra Automode
      NoActAFeedbackA : BOOL ;	//    Modeswitch No action and feedback alarm
      StopIfA : BOOL ;	//    Modeswitch Stop if alarm
      RestrtAftBlack : BOOL ;	//    Modeswitch Restart after Blackout
      RstAStartStop : BOOL ;	//    Modeswitch Reset Alarm with Start /Stop
      CmdTdly : BOOL ;	//    Modeswitch Command time delay
      LockBlockCmd : BOOL ;	//    Modeswitch Lock blocksCommands
     END_STRUCT ;
     DlyTCmd : TIME ;	//Setpoint command time delay
     DlyTBlackout : TIME ;	//Setpoint blackout time delay
     DlyTExtFault : TIME ;	//Setpoint external fault delay
     DlyTFeedback : TIME ;	//Setpoint feedback fault delay
     DlyTStrtActFault : TIME ;	//Setpoint start action delay
     DlyTAutoAl : TIME ;	//Setpoint auto alarm delay
     DlyTRestart : TIME ;	//Setpoint restart after blackout delay
     DlyTStpActFault : TIME ;	//Setpoint stop action fault
    END_STRUCT ;
   END_STRUCT ;
  END_STRUCT ;
BEGIN
   MOTOR1_No001.System := W#16#0;
   MOTOR1_No001.CmdOS := W#16#0;
   MOTOR1_No001.MirrorCmdOS := W#16#0;
   MOTOR1_No001.Test := W#16#0;
   MOTOR1_No001.AlarmOS := W#16#0;
   MOTOR1_No001.StatusOS := W#16#0;
   MOTOR1_No001.SysStatusOS := W#16#0;
   MOTOR1_No001.Status1 := W#16#0;
   MOTOR1_No001.Status2 := W#16#0;
   MOTOR1_No001.InputEdges := W#16#0;
   MOTOR1_No001.AutoEdges := W#16#0;
   MOTOR1_No001.DataTimeCmd.StartTime := L#0;
   MOTOR1_No001.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No001.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No001.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No001.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No001.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No001.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No001.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No001.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No001.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No001.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No001.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No001.DataTimeRestart.StartTime := L#0;
   MOTOR1_No001.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No001.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No001.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.DlyAFaultStop := TRUE;
   MOTOR1_No001.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No001.PCONF.Modeswitches.ExtraAutomode := TRUE;
   MOTOR1_No001.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.StopIfA := TRUE;
   MOTOR1_No001.PCONF.Modeswitches.RestrtAftBlack := TRUE;
   MOTOR1_No001.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No001.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No001.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No001.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No001.PCONF.DlyTExtFault := T#5S;
   MOTOR1_No001.PCONF.DlyTFeedback := T#10S;
   MOTOR1_No001.PCONF.DlyTStrtActFault := T#20S;
   MOTOR1_No001.PCONF.DlyTAutoAl := T#15S;
   MOTOR1_No001.PCONF.DlyTRestart := T#1M;
   MOTOR1_No001.PCONF.DlyTStpActFault := T#10S;
   MOTOR1_No002.System := W#16#0;
   MOTOR1_No002.CmdOS := W#16#0;
   MOTOR1_No002.MirrorCmdOS := W#16#0;
   MOTOR1_No002.Test := W#16#0;
   MOTOR1_No002.AlarmOS := W#16#0;
   MOTOR1_No002.StatusOS := W#16#0;
   MOTOR1_No002.SysStatusOS := W#16#0;
   MOTOR1_No002.Status1 := W#16#0;
   MOTOR1_No002.Status2 := W#16#0;
   MOTOR1_No002.InputEdges := W#16#0;
   MOTOR1_No002.AutoEdges := W#16#0;
   MOTOR1_No002.DataTimeCmd.StartTime := L#0;
   MOTOR1_No002.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No002.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No002.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No002.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No002.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No002.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No002.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No002.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No002.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No002.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No002.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No002.DataTimeRestart.StartTime := L#0;
   MOTOR1_No002.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No002.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No002.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No002.PCONF.Modeswitches.ExtraAutomode := TRUE;
   MOTOR1_No002.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.StopIfA := TRUE;
   MOTOR1_No002.PCONF.Modeswitches.RestrtAftBlack := TRUE;
   MOTOR1_No002.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No002.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No002.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No002.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No002.PCONF.DlyTExtFault := T#5S;
   MOTOR1_No002.PCONF.DlyTFeedback := T#10S;
   MOTOR1_No002.PCONF.DlyTStrtActFault := T#20S;
   MOTOR1_No002.PCONF.DlyTAutoAl := T#15S;
   MOTOR1_No002.PCONF.DlyTRestart := T#1M;
   MOTOR1_No002.PCONF.DlyTStpActFault := T#10S;
   MOTOR1_No003.System := W#16#0;
   MOTOR1_No003.CmdOS := W#16#0;
   MOTOR1_No003.MirrorCmdOS := W#16#0;
   MOTOR1_No003.Test := W#16#0;
   MOTOR1_No003.AlarmOS := W#16#0;
   MOTOR1_No003.StatusOS := W#16#0;
   MOTOR1_No003.SysStatusOS := W#16#0;
   MOTOR1_No003.Status1 := W#16#0;
   MOTOR1_No003.Status2 := W#16#0;
   MOTOR1_No003.InputEdges := W#16#0;
   MOTOR1_No003.AutoEdges := W#16#0;
   MOTOR1_No003.DataTimeCmd.StartTime := L#0;
   MOTOR1_No003.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No003.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No003.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No003.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No003.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No003.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No003.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No003.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No003.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No003.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No003.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No003.DataTimeRestart.StartTime := L#0;
   MOTOR1_No003.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No003.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No003.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No003.PCONF.Modeswitches.ExtraAutomode := TRUE;
   MOTOR1_No003.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.StopIfA := TRUE;
   MOTOR1_No003.PCONF.Modeswitches.RestrtAftBlack := TRUE;
   MOTOR1_No003.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No003.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No003.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No003.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No003.PCONF.DlyTExtFault := T#5S;
   MOTOR1_No003.PCONF.DlyTFeedback := T#10S;
   MOTOR1_No003.PCONF.DlyTStrtActFault := T#20S;
   MOTOR1_No003.PCONF.DlyTAutoAl := T#15S;
   MOTOR1_No003.PCONF.DlyTRestart := T#1M;
   MOTOR1_No003.PCONF.DlyTStpActFault := T#10S;
   MOTOR1_No004.System := W#16#0;
   MOTOR1_No004.CmdOS := W#16#0;
   MOTOR1_No004.MirrorCmdOS := W#16#0;
   MOTOR1_No004.Test := W#16#0;
   MOTOR1_No004.AlarmOS := W#16#0;
   MOTOR1_No004.StatusOS := W#16#0;
   MOTOR1_No004.SysStatusOS := W#16#0;
   MOTOR1_No004.Status1 := W#16#0;
   MOTOR1_No004.Status2 := W#16#0;
   MOTOR1_No004.InputEdges := W#16#0;
   MOTOR1_No004.AutoEdges := W#16#0;
   MOTOR1_No004.DataTimeCmd.StartTime := L#0;
   MOTOR1_No004.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No004.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No004.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No004.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No004.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No004.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No004.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No004.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No004.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No004.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No004.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No004.DataTimeRestart.StartTime := L#0;
   MOTOR1_No004.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No004.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No004.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No004.PCONF.Modeswitches.ExtraAutomode := TRUE;
   MOTOR1_No004.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.StopIfA := TRUE;
   MOTOR1_No004.PCONF.Modeswitches.RestrtAftBlack := TRUE;
   MOTOR1_No004.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No004.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No004.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No004.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No004.PCONF.DlyTExtFault := T#5S;
   MOTOR1_No004.PCONF.DlyTFeedback := T#10S;
   MOTOR1_No004.PCONF.DlyTStrtActFault := T#20S;
   MOTOR1_No004.PCONF.DlyTAutoAl := T#15S;
   MOTOR1_No004.PCONF.DlyTRestart := T#1M;
   MOTOR1_No004.PCONF.DlyTStpActFault := T#10S;
   MOTOR1_No005.System := W#16#0;
   MOTOR1_No005.CmdOS := W#16#0;
   MOTOR1_No005.MirrorCmdOS := W#16#0;
   MOTOR1_No005.Test := W#16#0;
   MOTOR1_No005.AlarmOS := W#16#0;
   MOTOR1_No005.StatusOS := W#16#0;
   MOTOR1_No005.SysStatusOS := W#16#0;
   MOTOR1_No005.Status1 := W#16#0;
   MOTOR1_No005.Status2 := W#16#0;
   MOTOR1_No005.InputEdges := W#16#0;
   MOTOR1_No005.AutoEdges := W#16#0;
   MOTOR1_No005.DataTimeCmd.StartTime := L#0;
   MOTOR1_No005.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No005.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No005.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No005.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No005.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No005.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No005.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No005.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No005.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No005.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No005.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No005.DataTimeRestart.StartTime := L#0;
   MOTOR1_No005.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No005.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No005.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No005.PCONF.Modeswitches.ExtraAutomode := TRUE;
   MOTOR1_No005.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.StopIfA := TRUE;
   MOTOR1_No005.PCONF.Modeswitches.RestrtAftBlack := TRUE;
   MOTOR1_No005.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No005.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No005.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No005.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No005.PCONF.DlyTExtFault := T#5S;
   MOTOR1_No005.PCONF.DlyTFeedback := T#10S;
   MOTOR1_No005.PCONF.DlyTStrtActFault := T#20S;
   MOTOR1_No005.PCONF.DlyTAutoAl := T#15S;
   MOTOR1_No005.PCONF.DlyTRestart := T#1M;
   MOTOR1_No005.PCONF.DlyTStpActFault := T#10S;
   MOTOR1_No006.System := W#16#0;
   MOTOR1_No006.CmdOS := W#16#0;
   MOTOR1_No006.MirrorCmdOS := W#16#0;
   MOTOR1_No006.Test := W#16#0;
   MOTOR1_No006.AlarmOS := W#16#0;
   MOTOR1_No006.StatusOS := W#16#0;
   MOTOR1_No006.SysStatusOS := W#16#0;
   MOTOR1_No006.Status1 := W#16#0;
   MOTOR1_No006.Status2 := W#16#0;
   MOTOR1_No006.InputEdges := W#16#0;
   MOTOR1_No006.AutoEdges := W#16#0;
   MOTOR1_No006.DataTimeCmd.StartTime := L#0;
   MOTOR1_No006.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No006.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No006.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No006.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No006.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No006.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No006.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No006.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No006.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No006.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No006.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No006.DataTimeRestart.StartTime := L#0;
   MOTOR1_No006.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No006.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No006.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No006.PCONF.Modeswitches.ExtraAutomode := TRUE;
   MOTOR1_No006.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.StopIfA := TRUE;
   MOTOR1_No006.PCONF.Modeswitches.RestrtAftBlack := TRUE;
   MOTOR1_No006.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No006.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No006.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No006.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No006.PCONF.DlyTExtFault := T#5S;
   MOTOR1_No006.PCONF.DlyTFeedback := T#10S;
   MOTOR1_No006.PCONF.DlyTStrtActFault := T#20S;
   MOTOR1_No006.PCONF.DlyTAutoAl := T#15S;
   MOTOR1_No006.PCONF.DlyTRestart := T#1M;
   MOTOR1_No006.PCONF.DlyTStpActFault := T#10S;
   MOTOR1_No007.System := W#16#0;
   MOTOR1_No007.CmdOS := W#16#0;
   MOTOR1_No007.MirrorCmdOS := W#16#0;
   MOTOR1_No007.Test := W#16#0;
   MOTOR1_No007.AlarmOS := W#16#0;
   MOTOR1_No007.StatusOS := W#16#0;
   MOTOR1_No007.SysStatusOS := W#16#0;
   MOTOR1_No007.Status1 := W#16#0;
   MOTOR1_No007.Status2 := W#16#0;
   MOTOR1_No007.InputEdges := W#16#0;
   MOTOR1_No007.AutoEdges := W#16#0;
   MOTOR1_No007.DataTimeCmd.StartTime := L#0;
   MOTOR1_No007.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No007.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No007.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No007.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No007.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No007.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No007.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No007.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No007.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No007.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No007.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No007.DataTimeRestart.StartTime := L#0;
   MOTOR1_No007.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No007.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No007.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.ConstOutput := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No007.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No007.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No007.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No007.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No007.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No007.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No007.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No007.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No007.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No008.System := W#16#0;
   MOTOR1_No008.CmdOS := W#16#0;
   MOTOR1_No008.MirrorCmdOS := W#16#0;
   MOTOR1_No008.Test := W#16#0;
   MOTOR1_No008.AlarmOS := W#16#0;
   MOTOR1_No008.StatusOS := W#16#0;
   MOTOR1_No008.SysStatusOS := W#16#0;
   MOTOR1_No008.Status1 := W#16#0;
   MOTOR1_No008.Status2 := W#16#0;
   MOTOR1_No008.InputEdges := W#16#0;
   MOTOR1_No008.AutoEdges := W#16#0;
   MOTOR1_No008.DataTimeCmd.StartTime := L#0;
   MOTOR1_No008.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No008.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No008.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No008.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No008.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No008.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No008.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No008.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No008.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No008.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No008.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No008.DataTimeRestart.StartTime := L#0;
   MOTOR1_No008.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No008.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No008.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.ConstOutput := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No008.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No008.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No008.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No008.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No008.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No008.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No008.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No008.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No008.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No009.System := W#16#0;
   MOTOR1_No009.CmdOS := W#16#0;
   MOTOR1_No009.MirrorCmdOS := W#16#0;
   MOTOR1_No009.Test := W#16#0;
   MOTOR1_No009.AlarmOS := W#16#0;
   MOTOR1_No009.StatusOS := W#16#0;
   MOTOR1_No009.SysStatusOS := W#16#0;
   MOTOR1_No009.Status1 := W#16#0;
   MOTOR1_No009.Status2 := W#16#0;
   MOTOR1_No009.InputEdges := W#16#0;
   MOTOR1_No009.AutoEdges := W#16#0;
   MOTOR1_No009.DataTimeCmd.StartTime := L#0;
   MOTOR1_No009.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No009.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No009.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No009.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No009.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No009.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No009.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No009.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No009.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No009.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No009.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No009.DataTimeRestart.StartTime := L#0;
   MOTOR1_No009.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No009.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No009.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.ConstOutput := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No009.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No009.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No009.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No009.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No009.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No009.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No009.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No009.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No009.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No010.System := W#16#0;
   MOTOR1_No010.CmdOS := W#16#0;
   MOTOR1_No010.MirrorCmdOS := W#16#0;
   MOTOR1_No010.Test := W#16#0;
   MOTOR1_No010.AlarmOS := W#16#0;
   MOTOR1_No010.StatusOS := W#16#0;
   MOTOR1_No010.SysStatusOS := W#16#0;
   MOTOR1_No010.Status1 := W#16#0;
   MOTOR1_No010.Status2 := W#16#0;
   MOTOR1_No010.InputEdges := W#16#0;
   MOTOR1_No010.AutoEdges := W#16#0;
   MOTOR1_No010.DataTimeCmd.StartTime := L#0;
   MOTOR1_No010.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No010.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No010.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No010.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No010.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No010.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No010.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No010.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No010.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No010.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No010.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No010.DataTimeRestart.StartTime := L#0;
   MOTOR1_No010.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No010.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No010.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.ConstOutput := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No010.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No010.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No010.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No010.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No010.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No010.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No010.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No010.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No010.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No011.System := W#16#0;
   MOTOR1_No011.CmdOS := W#16#0;
   MOTOR1_No011.MirrorCmdOS := W#16#0;
   MOTOR1_No011.Test := W#16#0;
   MOTOR1_No011.AlarmOS := W#16#0;
   MOTOR1_No011.StatusOS := W#16#0;
   MOTOR1_No011.SysStatusOS := W#16#0;
   MOTOR1_No011.Status1 := W#16#0;
   MOTOR1_No011.Status2 := W#16#0;
   MOTOR1_No011.InputEdges := W#16#0;
   MOTOR1_No011.AutoEdges := W#16#0;
   MOTOR1_No011.DataTimeCmd.StartTime := L#0;
   MOTOR1_No011.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No011.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No011.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No011.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No011.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No011.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No011.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No011.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No011.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No011.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No011.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No011.DataTimeRestart.StartTime := L#0;
   MOTOR1_No011.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No011.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No011.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No011.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No011.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No011.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No011.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No011.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No011.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No011.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No011.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No011.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No011.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No012.System := W#16#0;
   MOTOR1_No012.CmdOS := W#16#0;
   MOTOR1_No012.MirrorCmdOS := W#16#0;
   MOTOR1_No012.Test := W#16#0;
   MOTOR1_No012.AlarmOS := W#16#0;
   MOTOR1_No012.StatusOS := W#16#0;
   MOTOR1_No012.SysStatusOS := W#16#0;
   MOTOR1_No012.Status1 := W#16#0;
   MOTOR1_No012.Status2 := W#16#0;
   MOTOR1_No012.InputEdges := W#16#0;
   MOTOR1_No012.AutoEdges := W#16#0;
   MOTOR1_No012.DataTimeCmd.StartTime := L#0;
   MOTOR1_No012.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No012.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No012.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No012.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No012.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No012.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No012.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No012.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No012.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No012.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No012.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No012.DataTimeRestart.StartTime := L#0;
   MOTOR1_No012.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No012.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No012.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No012.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No012.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No012.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No012.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No012.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No012.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No012.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No012.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No012.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No012.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No013.System := W#16#0;
   MOTOR1_No013.CmdOS := W#16#0;
   MOTOR1_No013.MirrorCmdOS := W#16#0;
   MOTOR1_No013.Test := W#16#0;
   MOTOR1_No013.AlarmOS := W#16#0;
   MOTOR1_No013.StatusOS := W#16#0;
   MOTOR1_No013.SysStatusOS := W#16#0;
   MOTOR1_No013.Status1 := W#16#0;
   MOTOR1_No013.Status2 := W#16#0;
   MOTOR1_No013.InputEdges := W#16#0;
   MOTOR1_No013.AutoEdges := W#16#0;
   MOTOR1_No013.DataTimeCmd.StartTime := L#0;
   MOTOR1_No013.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No013.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No013.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No013.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No013.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No013.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No013.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No013.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No013.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No013.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No013.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No013.DataTimeRestart.StartTime := L#0;
   MOTOR1_No013.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No013.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No013.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No013.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No013.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No013.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No013.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No013.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No013.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No013.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No013.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No013.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No013.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No014.System := W#16#0;
   MOTOR1_No014.CmdOS := W#16#0;
   MOTOR1_No014.MirrorCmdOS := W#16#0;
   MOTOR1_No014.Test := W#16#0;
   MOTOR1_No014.AlarmOS := W#16#0;
   MOTOR1_No014.StatusOS := W#16#0;
   MOTOR1_No014.SysStatusOS := W#16#0;
   MOTOR1_No014.Status1 := W#16#0;
   MOTOR1_No014.Status2 := W#16#0;
   MOTOR1_No014.InputEdges := W#16#0;
   MOTOR1_No014.AutoEdges := W#16#0;
   MOTOR1_No014.DataTimeCmd.StartTime := L#0;
   MOTOR1_No014.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No014.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No014.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No014.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No014.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No014.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No014.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No014.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No014.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No014.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No014.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No014.DataTimeRestart.StartTime := L#0;
   MOTOR1_No014.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No014.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No014.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No014.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No014.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No014.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No014.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No014.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No014.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No014.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No014.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No014.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No014.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No015.System := W#16#0;
   MOTOR1_No015.CmdOS := W#16#0;
   MOTOR1_No015.MirrorCmdOS := W#16#0;
   MOTOR1_No015.Test := W#16#0;
   MOTOR1_No015.AlarmOS := W#16#0;
   MOTOR1_No015.StatusOS := W#16#0;
   MOTOR1_No015.SysStatusOS := W#16#0;
   MOTOR1_No015.Status1 := W#16#0;
   MOTOR1_No015.Status2 := W#16#0;
   MOTOR1_No015.InputEdges := W#16#0;
   MOTOR1_No015.AutoEdges := W#16#0;
   MOTOR1_No015.DataTimeCmd.StartTime := L#0;
   MOTOR1_No015.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No015.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No015.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No015.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No015.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No015.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No015.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No015.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No015.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No015.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No015.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No015.DataTimeRestart.StartTime := L#0;
   MOTOR1_No015.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No015.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No015.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No015.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No015.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No015.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No015.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No015.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No015.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No015.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No015.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No015.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No015.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No016.System := W#16#0;
   MOTOR1_No016.CmdOS := W#16#0;
   MOTOR1_No016.MirrorCmdOS := W#16#0;
   MOTOR1_No016.Test := W#16#0;
   MOTOR1_No016.AlarmOS := W#16#0;
   MOTOR1_No016.StatusOS := W#16#0;
   MOTOR1_No016.SysStatusOS := W#16#0;
   MOTOR1_No016.Status1 := W#16#0;
   MOTOR1_No016.Status2 := W#16#0;
   MOTOR1_No016.InputEdges := W#16#0;
   MOTOR1_No016.AutoEdges := W#16#0;
   MOTOR1_No016.DataTimeCmd.StartTime := L#0;
   MOTOR1_No016.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No016.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No016.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No016.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No016.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No016.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No016.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No016.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No016.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No016.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No016.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No016.DataTimeRestart.StartTime := L#0;
   MOTOR1_No016.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No016.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No016.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No016.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No016.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No016.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No016.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No016.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No016.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No016.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No016.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No016.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No016.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No017.System := W#16#0;
   MOTOR1_No017.CmdOS := W#16#0;
   MOTOR1_No017.MirrorCmdOS := W#16#0;
   MOTOR1_No017.Test := W#16#0;
   MOTOR1_No017.AlarmOS := W#16#0;
   MOTOR1_No017.StatusOS := W#16#0;
   MOTOR1_No017.SysStatusOS := W#16#0;
   MOTOR1_No017.Status1 := W#16#0;
   MOTOR1_No017.Status2 := W#16#0;
   MOTOR1_No017.InputEdges := W#16#0;
   MOTOR1_No017.AutoEdges := W#16#0;
   MOTOR1_No017.DataTimeCmd.StartTime := L#0;
   MOTOR1_No017.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No017.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No017.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No017.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No017.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No017.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No017.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No017.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No017.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No017.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No017.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No017.DataTimeRestart.StartTime := L#0;
   MOTOR1_No017.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No017.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No017.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No017.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No017.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No017.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No017.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No017.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No017.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No017.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No017.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No017.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No017.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No018.System := W#16#0;
   MOTOR1_No018.CmdOS := W#16#0;
   MOTOR1_No018.MirrorCmdOS := W#16#0;
   MOTOR1_No018.Test := W#16#0;
   MOTOR1_No018.AlarmOS := W#16#0;
   MOTOR1_No018.StatusOS := W#16#0;
   MOTOR1_No018.SysStatusOS := W#16#0;
   MOTOR1_No018.Status1 := W#16#0;
   MOTOR1_No018.Status2 := W#16#0;
   MOTOR1_No018.InputEdges := W#16#0;
   MOTOR1_No018.AutoEdges := W#16#0;
   MOTOR1_No018.DataTimeCmd.StartTime := L#0;
   MOTOR1_No018.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No018.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No018.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No018.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No018.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No018.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No018.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No018.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No018.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No018.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No018.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No018.DataTimeRestart.StartTime := L#0;
   MOTOR1_No018.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No018.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No018.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No018.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No018.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No018.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No018.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No018.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No018.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No018.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No018.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No018.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No018.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No0119.System := W#16#0;
   MOTOR1_No0119.CmdOS := W#16#0;
   MOTOR1_No0119.MirrorCmdOS := W#16#0;
   MOTOR1_No0119.Test := W#16#0;
   MOTOR1_No0119.AlarmOS := W#16#0;
   MOTOR1_No0119.StatusOS := W#16#0;
   MOTOR1_No0119.SysStatusOS := W#16#0;
   MOTOR1_No0119.Status1 := W#16#0;
   MOTOR1_No0119.Status2 := W#16#0;
   MOTOR1_No0119.InputEdges := W#16#0;
   MOTOR1_No0119.AutoEdges := W#16#0;
   MOTOR1_No0119.DataTimeCmd.StartTime := L#0;
   MOTOR1_No0119.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No0119.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No0119.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No0119.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No0119.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No0119.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeRestart.StartTime := L#0;
   MOTOR1_No0119.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No0119.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No0119.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No0119.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No0119.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No0119.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No0119.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No0119.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No0119.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No0119.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No0119.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No0119.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No0119.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No020.System := W#16#0;
   MOTOR1_No020.CmdOS := W#16#0;
   MOTOR1_No020.MirrorCmdOS := W#16#0;
   MOTOR1_No020.Test := W#16#0;
   MOTOR1_No020.AlarmOS := W#16#0;
   MOTOR1_No020.StatusOS := W#16#0;
   MOTOR1_No020.SysStatusOS := W#16#0;
   MOTOR1_No020.Status1 := W#16#0;
   MOTOR1_No020.Status2 := W#16#0;
   MOTOR1_No020.InputEdges := W#16#0;
   MOTOR1_No020.AutoEdges := W#16#0;
   MOTOR1_No020.DataTimeCmd.StartTime := L#0;
   MOTOR1_No020.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No020.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No020.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No020.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No020.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No020.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No020.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No020.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No020.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No020.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No020.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No020.DataTimeRestart.StartTime := L#0;
   MOTOR1_No020.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No020.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No020.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No020.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No020.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No020.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No020.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No020.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No020.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No020.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No020.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No020.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No020.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No021.System := W#16#0;
   MOTOR1_No021.CmdOS := W#16#0;
   MOTOR1_No021.MirrorCmdOS := W#16#0;
   MOTOR1_No021.Test := W#16#0;
   MOTOR1_No021.AlarmOS := W#16#0;
   MOTOR1_No021.StatusOS := W#16#0;
   MOTOR1_No021.SysStatusOS := W#16#0;
   MOTOR1_No021.Status1 := W#16#0;
   MOTOR1_No021.Status2 := W#16#0;
   MOTOR1_No021.InputEdges := W#16#0;
   MOTOR1_No021.AutoEdges := W#16#0;
   MOTOR1_No021.DataTimeCmd.StartTime := L#0;
   MOTOR1_No021.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No021.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No021.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No021.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No021.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No021.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No021.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No021.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No021.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No021.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No021.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No021.DataTimeRestart.StartTime := L#0;
   MOTOR1_No021.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No021.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No021.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No021.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No021.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No021.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No021.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No021.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No021.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No021.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No021.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No021.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No021.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No022.System := W#16#0;
   MOTOR1_No022.CmdOS := W#16#0;
   MOTOR1_No022.MirrorCmdOS := W#16#0;
   MOTOR1_No022.Test := W#16#0;
   MOTOR1_No022.AlarmOS := W#16#0;
   MOTOR1_No022.StatusOS := W#16#0;
   MOTOR1_No022.SysStatusOS := W#16#0;
   MOTOR1_No022.Status1 := W#16#0;
   MOTOR1_No022.Status2 := W#16#0;
   MOTOR1_No022.InputEdges := W#16#0;
   MOTOR1_No022.AutoEdges := W#16#0;
   MOTOR1_No022.DataTimeCmd.StartTime := L#0;
   MOTOR1_No022.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No022.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No022.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No022.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No022.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No022.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No022.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No022.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No022.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No022.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No022.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No022.DataTimeRestart.StartTime := L#0;
   MOTOR1_No022.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No022.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No022.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No022.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No022.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No022.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No022.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No022.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No022.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No022.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No022.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No022.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No022.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No023.System := W#16#0;
   MOTOR1_No023.CmdOS := W#16#0;
   MOTOR1_No023.MirrorCmdOS := W#16#0;
   MOTOR1_No023.Test := W#16#0;
   MOTOR1_No023.AlarmOS := W#16#0;
   MOTOR1_No023.StatusOS := W#16#0;
   MOTOR1_No023.SysStatusOS := W#16#0;
   MOTOR1_No023.Status1 := W#16#0;
   MOTOR1_No023.Status2 := W#16#0;
   MOTOR1_No023.InputEdges := W#16#0;
   MOTOR1_No023.AutoEdges := W#16#0;
   MOTOR1_No023.DataTimeCmd.StartTime := L#0;
   MOTOR1_No023.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No023.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No023.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No023.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No023.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No023.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No023.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No023.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No023.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No023.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No023.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No023.DataTimeRestart.StartTime := L#0;
   MOTOR1_No023.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No023.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No023.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No023.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No023.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No023.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No023.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No023.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No023.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No023.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No023.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No023.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No023.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No024.System := W#16#0;
   MOTOR1_No024.CmdOS := W#16#0;
   MOTOR1_No024.MirrorCmdOS := W#16#0;
   MOTOR1_No024.Test := W#16#0;
   MOTOR1_No024.AlarmOS := W#16#0;
   MOTOR1_No024.StatusOS := W#16#0;
   MOTOR1_No024.SysStatusOS := W#16#0;
   MOTOR1_No024.Status1 := W#16#0;
   MOTOR1_No024.Status2 := W#16#0;
   MOTOR1_No024.InputEdges := W#16#0;
   MOTOR1_No024.AutoEdges := W#16#0;
   MOTOR1_No024.DataTimeCmd.StartTime := L#0;
   MOTOR1_No024.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No024.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No024.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No024.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No024.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No024.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No024.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No024.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No024.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No024.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No024.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No024.DataTimeRestart.StartTime := L#0;
   MOTOR1_No024.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No024.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No024.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No024.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No024.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No024.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No024.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No024.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No024.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No024.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No024.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No024.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No024.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No025.System := W#16#0;
   MOTOR1_No025.CmdOS := W#16#0;
   MOTOR1_No025.MirrorCmdOS := W#16#0;
   MOTOR1_No025.Test := W#16#0;
   MOTOR1_No025.AlarmOS := W#16#0;
   MOTOR1_No025.StatusOS := W#16#0;
   MOTOR1_No025.SysStatusOS := W#16#0;
   MOTOR1_No025.Status1 := W#16#0;
   MOTOR1_No025.Status2 := W#16#0;
   MOTOR1_No025.InputEdges := W#16#0;
   MOTOR1_No025.AutoEdges := W#16#0;
   MOTOR1_No025.DataTimeCmd.StartTime := L#0;
   MOTOR1_No025.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No025.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No025.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No025.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No025.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No025.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No025.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No025.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No025.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No025.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No025.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No025.DataTimeRestart.StartTime := L#0;
   MOTOR1_No025.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No025.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No025.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No025.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No025.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No025.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No025.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No025.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No025.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No025.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No025.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No025.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No025.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No026.System := W#16#0;
   MOTOR1_No026.CmdOS := W#16#0;
   MOTOR1_No026.MirrorCmdOS := W#16#0;
   MOTOR1_No026.Test := W#16#0;
   MOTOR1_No026.AlarmOS := W#16#0;
   MOTOR1_No026.StatusOS := W#16#0;
   MOTOR1_No026.SysStatusOS := W#16#0;
   MOTOR1_No026.Status1 := W#16#0;
   MOTOR1_No026.Status2 := W#16#0;
   MOTOR1_No026.InputEdges := W#16#0;
   MOTOR1_No026.AutoEdges := W#16#0;
   MOTOR1_No026.DataTimeCmd.StartTime := L#0;
   MOTOR1_No026.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No026.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No026.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No026.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No026.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No026.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No026.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No026.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No026.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No026.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No026.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No026.DataTimeRestart.StartTime := L#0;
   MOTOR1_No026.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No026.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No026.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No026.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No026.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No026.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No026.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No026.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No026.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No026.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No026.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No026.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No026.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No027.System := W#16#0;
   MOTOR1_No027.CmdOS := W#16#0;
   MOTOR1_No027.MirrorCmdOS := W#16#0;
   MOTOR1_No027.Test := W#16#0;
   MOTOR1_No027.AlarmOS := W#16#0;
   MOTOR1_No027.StatusOS := W#16#0;
   MOTOR1_No027.SysStatusOS := W#16#0;
   MOTOR1_No027.Status1 := W#16#0;
   MOTOR1_No027.Status2 := W#16#0;
   MOTOR1_No027.InputEdges := W#16#0;
   MOTOR1_No027.AutoEdges := W#16#0;
   MOTOR1_No027.DataTimeCmd.StartTime := L#0;
   MOTOR1_No027.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No027.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No027.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No027.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No027.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No027.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No027.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No027.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No027.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No027.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No027.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No027.DataTimeRestart.StartTime := L#0;
   MOTOR1_No027.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No027.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No027.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No027.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No027.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No027.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No027.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No027.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No027.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No027.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No027.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No027.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No027.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No028.System := W#16#0;
   MOTOR1_No028.CmdOS := W#16#0;
   MOTOR1_No028.MirrorCmdOS := W#16#0;
   MOTOR1_No028.Test := W#16#0;
   MOTOR1_No028.AlarmOS := W#16#0;
   MOTOR1_No028.StatusOS := W#16#0;
   MOTOR1_No028.SysStatusOS := W#16#0;
   MOTOR1_No028.Status1 := W#16#0;
   MOTOR1_No028.Status2 := W#16#0;
   MOTOR1_No028.InputEdges := W#16#0;
   MOTOR1_No028.AutoEdges := W#16#0;
   MOTOR1_No028.DataTimeCmd.StartTime := L#0;
   MOTOR1_No028.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No028.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No028.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No028.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No028.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No028.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No028.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No028.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No028.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No028.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No028.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No028.DataTimeRestart.StartTime := L#0;
   MOTOR1_No028.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No028.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No028.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No028.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No028.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No028.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No028.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No028.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No028.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No028.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No028.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No028.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No028.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No029.System := W#16#0;
   MOTOR1_No029.CmdOS := W#16#0;
   MOTOR1_No029.MirrorCmdOS := W#16#0;
   MOTOR1_No029.Test := W#16#0;
   MOTOR1_No029.AlarmOS := W#16#0;
   MOTOR1_No029.StatusOS := W#16#0;
   MOTOR1_No029.SysStatusOS := W#16#0;
   MOTOR1_No029.Status1 := W#16#0;
   MOTOR1_No029.Status2 := W#16#0;
   MOTOR1_No029.InputEdges := W#16#0;
   MOTOR1_No029.AutoEdges := W#16#0;
   MOTOR1_No029.DataTimeCmd.StartTime := L#0;
   MOTOR1_No029.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No029.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No029.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No029.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No029.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No029.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No029.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No029.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No029.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No029.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No029.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No029.DataTimeRestart.StartTime := L#0;
   MOTOR1_No029.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No029.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No029.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No029.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No029.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No029.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No029.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No029.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No029.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No029.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No029.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No029.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No029.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No030.System := W#16#0;
   MOTOR1_No030.CmdOS := W#16#0;
   MOTOR1_No030.MirrorCmdOS := W#16#0;
   MOTOR1_No030.Test := W#16#0;
   MOTOR1_No030.AlarmOS := W#16#0;
   MOTOR1_No030.StatusOS := W#16#0;
   MOTOR1_No030.SysStatusOS := W#16#0;
   MOTOR1_No030.Status1 := W#16#0;
   MOTOR1_No030.Status2 := W#16#0;
   MOTOR1_No030.InputEdges := W#16#0;
   MOTOR1_No030.AutoEdges := W#16#0;
   MOTOR1_No030.DataTimeCmd.StartTime := L#0;
   MOTOR1_No030.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No030.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No030.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No030.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No030.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No030.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No030.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No030.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No030.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No030.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No030.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No030.DataTimeRestart.StartTime := L#0;
   MOTOR1_No030.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No030.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No030.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No030.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No030.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No030.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No030.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No030.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No030.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No030.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No030.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No030.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No030.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No031.System := W#16#0;
   MOTOR1_No031.CmdOS := W#16#0;
   MOTOR1_No031.MirrorCmdOS := W#16#0;
   MOTOR1_No031.Test := W#16#0;
   MOTOR1_No031.AlarmOS := W#16#0;
   MOTOR1_No031.StatusOS := W#16#0;
   MOTOR1_No031.SysStatusOS := W#16#0;
   MOTOR1_No031.Status1 := W#16#0;
   MOTOR1_No031.Status2 := W#16#0;
   MOTOR1_No031.InputEdges := W#16#0;
   MOTOR1_No031.AutoEdges := W#16#0;
   MOTOR1_No031.DataTimeCmd.StartTime := L#0;
   MOTOR1_No031.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No031.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No031.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No031.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No031.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No031.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No031.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No031.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No031.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No031.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No031.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No031.DataTimeRestart.StartTime := L#0;
   MOTOR1_No031.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No031.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No031.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No031.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No031.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No031.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No031.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No031.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No031.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No031.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No031.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No031.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No031.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No032.System := W#16#0;
   MOTOR1_No032.CmdOS := W#16#0;
   MOTOR1_No032.MirrorCmdOS := W#16#0;
   MOTOR1_No032.Test := W#16#0;
   MOTOR1_No032.AlarmOS := W#16#0;
   MOTOR1_No032.StatusOS := W#16#0;
   MOTOR1_No032.SysStatusOS := W#16#0;
   MOTOR1_No032.Status1 := W#16#0;
   MOTOR1_No032.Status2 := W#16#0;
   MOTOR1_No032.InputEdges := W#16#0;
   MOTOR1_No032.AutoEdges := W#16#0;
   MOTOR1_No032.DataTimeCmd.StartTime := L#0;
   MOTOR1_No032.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No032.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No032.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No032.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No032.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No032.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No032.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No032.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No032.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No032.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No032.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No032.DataTimeRestart.StartTime := L#0;
   MOTOR1_No032.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No032.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No032.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No032.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No032.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No032.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No032.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No032.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No032.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No032.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No032.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No032.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No032.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No033.System := W#16#0;
   MOTOR1_No033.CmdOS := W#16#0;
   MOTOR1_No033.MirrorCmdOS := W#16#0;
   MOTOR1_No033.Test := W#16#0;
   MOTOR1_No033.AlarmOS := W#16#0;
   MOTOR1_No033.StatusOS := W#16#0;
   MOTOR1_No033.SysStatusOS := W#16#0;
   MOTOR1_No033.Status1 := W#16#0;
   MOTOR1_No033.Status2 := W#16#0;
   MOTOR1_No033.InputEdges := W#16#0;
   MOTOR1_No033.AutoEdges := W#16#0;
   MOTOR1_No033.DataTimeCmd.StartTime := L#0;
   MOTOR1_No033.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No033.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No033.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No033.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No033.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No033.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No033.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No033.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No033.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No033.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No033.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No033.DataTimeRestart.StartTime := L#0;
   MOTOR1_No033.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No033.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No033.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No033.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No033.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No033.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No033.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No033.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No033.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No033.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No033.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No033.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No033.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No034.System := W#16#0;
   MOTOR1_No034.CmdOS := W#16#0;
   MOTOR1_No034.MirrorCmdOS := W#16#0;
   MOTOR1_No034.Test := W#16#0;
   MOTOR1_No034.AlarmOS := W#16#0;
   MOTOR1_No034.StatusOS := W#16#0;
   MOTOR1_No034.SysStatusOS := W#16#0;
   MOTOR1_No034.Status1 := W#16#0;
   MOTOR1_No034.Status2 := W#16#0;
   MOTOR1_No034.InputEdges := W#16#0;
   MOTOR1_No034.AutoEdges := W#16#0;
   MOTOR1_No034.DataTimeCmd.StartTime := L#0;
   MOTOR1_No034.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No034.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No034.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No034.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No034.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No034.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No034.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No034.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No034.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No034.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No034.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No034.DataTimeRestart.StartTime := L#0;
   MOTOR1_No034.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No034.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No034.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No034.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No034.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No034.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No034.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No034.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No034.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No034.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No034.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No034.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No034.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No035.System := W#16#0;
   MOTOR1_No035.CmdOS := W#16#0;
   MOTOR1_No035.MirrorCmdOS := W#16#0;
   MOTOR1_No035.Test := W#16#0;
   MOTOR1_No035.AlarmOS := W#16#0;
   MOTOR1_No035.StatusOS := W#16#0;
   MOTOR1_No035.SysStatusOS := W#16#0;
   MOTOR1_No035.Status1 := W#16#0;
   MOTOR1_No035.Status2 := W#16#0;
   MOTOR1_No035.InputEdges := W#16#0;
   MOTOR1_No035.AutoEdges := W#16#0;
   MOTOR1_No035.DataTimeCmd.StartTime := L#0;
   MOTOR1_No035.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No035.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No035.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No035.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No035.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No035.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No035.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No035.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No035.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No035.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No035.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No035.DataTimeRestart.StartTime := L#0;
   MOTOR1_No035.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No035.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No035.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No035.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No035.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No035.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No035.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No035.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No035.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No035.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No035.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No035.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No035.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No036.System := W#16#0;
   MOTOR1_No036.CmdOS := W#16#0;
   MOTOR1_No036.MirrorCmdOS := W#16#0;
   MOTOR1_No036.Test := W#16#0;
   MOTOR1_No036.AlarmOS := W#16#0;
   MOTOR1_No036.StatusOS := W#16#0;
   MOTOR1_No036.SysStatusOS := W#16#0;
   MOTOR1_No036.Status1 := W#16#0;
   MOTOR1_No036.Status2 := W#16#0;
   MOTOR1_No036.InputEdges := W#16#0;
   MOTOR1_No036.AutoEdges := W#16#0;
   MOTOR1_No036.DataTimeCmd.StartTime := L#0;
   MOTOR1_No036.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No036.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No036.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No036.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No036.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No036.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No036.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No036.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No036.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No036.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No036.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No036.DataTimeRestart.StartTime := L#0;
   MOTOR1_No036.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No036.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No036.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No036.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No036.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No036.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No036.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No036.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No036.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No036.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No036.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No036.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No036.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No037.System := W#16#0;
   MOTOR1_No037.CmdOS := W#16#0;
   MOTOR1_No037.MirrorCmdOS := W#16#0;
   MOTOR1_No037.Test := W#16#0;
   MOTOR1_No037.AlarmOS := W#16#0;
   MOTOR1_No037.StatusOS := W#16#0;
   MOTOR1_No037.SysStatusOS := W#16#0;
   MOTOR1_No037.Status1 := W#16#0;
   MOTOR1_No037.Status2 := W#16#0;
   MOTOR1_No037.InputEdges := W#16#0;
   MOTOR1_No037.AutoEdges := W#16#0;
   MOTOR1_No037.DataTimeCmd.StartTime := L#0;
   MOTOR1_No037.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No037.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No037.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No037.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No037.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No037.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No037.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No037.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No037.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No037.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No037.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No037.DataTimeRestart.StartTime := L#0;
   MOTOR1_No037.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No037.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No037.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No037.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No037.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No037.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No037.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No037.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No037.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No037.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No037.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No037.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No037.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No038.System := W#16#0;
   MOTOR1_No038.CmdOS := W#16#0;
   MOTOR1_No038.MirrorCmdOS := W#16#0;
   MOTOR1_No038.Test := W#16#0;
   MOTOR1_No038.AlarmOS := W#16#0;
   MOTOR1_No038.StatusOS := W#16#0;
   MOTOR1_No038.SysStatusOS := W#16#0;
   MOTOR1_No038.Status1 := W#16#0;
   MOTOR1_No038.Status2 := W#16#0;
   MOTOR1_No038.InputEdges := W#16#0;
   MOTOR1_No038.AutoEdges := W#16#0;
   MOTOR1_No038.DataTimeCmd.StartTime := L#0;
   MOTOR1_No038.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No038.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No038.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No038.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No038.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No038.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No038.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No038.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No038.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No038.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No038.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No038.DataTimeRestart.StartTime := L#0;
   MOTOR1_No038.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No038.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No038.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No038.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No038.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No038.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No038.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No038.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No038.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No038.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No038.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No038.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No038.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No039.System := W#16#0;
   MOTOR1_No039.CmdOS := W#16#0;
   MOTOR1_No039.MirrorCmdOS := W#16#0;
   MOTOR1_No039.Test := W#16#0;
   MOTOR1_No039.AlarmOS := W#16#0;
   MOTOR1_No039.StatusOS := W#16#0;
   MOTOR1_No039.SysStatusOS := W#16#0;
   MOTOR1_No039.Status1 := W#16#0;
   MOTOR1_No039.Status2 := W#16#0;
   MOTOR1_No039.InputEdges := W#16#0;
   MOTOR1_No039.AutoEdges := W#16#0;
   MOTOR1_No039.DataTimeCmd.StartTime := L#0;
   MOTOR1_No039.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No039.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No039.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No039.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No039.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No039.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No039.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No039.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No039.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No039.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No039.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No039.DataTimeRestart.StartTime := L#0;
   MOTOR1_No039.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No039.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No039.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No039.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No039.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No039.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No039.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No039.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No039.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No039.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No039.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No039.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No039.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No040.System := W#16#0;
   MOTOR1_No040.CmdOS := W#16#0;
   MOTOR1_No040.MirrorCmdOS := W#16#0;
   MOTOR1_No040.Test := W#16#0;
   MOTOR1_No040.AlarmOS := W#16#0;
   MOTOR1_No040.StatusOS := W#16#0;
   MOTOR1_No040.SysStatusOS := W#16#0;
   MOTOR1_No040.Status1 := W#16#0;
   MOTOR1_No040.Status2 := W#16#0;
   MOTOR1_No040.InputEdges := W#16#0;
   MOTOR1_No040.AutoEdges := W#16#0;
   MOTOR1_No040.DataTimeCmd.StartTime := L#0;
   MOTOR1_No040.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No040.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No040.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No040.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No040.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No040.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No040.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No040.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No040.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No040.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No040.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No040.DataTimeRestart.StartTime := L#0;
   MOTOR1_No040.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No040.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No040.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No040.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No040.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No040.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No040.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No040.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No040.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No040.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No040.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No040.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No040.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No041.System := W#16#0;
   MOTOR1_No041.CmdOS := W#16#0;
   MOTOR1_No041.MirrorCmdOS := W#16#0;
   MOTOR1_No041.Test := W#16#0;
   MOTOR1_No041.AlarmOS := W#16#0;
   MOTOR1_No041.StatusOS := W#16#0;
   MOTOR1_No041.SysStatusOS := W#16#0;
   MOTOR1_No041.Status1 := W#16#0;
   MOTOR1_No041.Status2 := W#16#0;
   MOTOR1_No041.InputEdges := W#16#0;
   MOTOR1_No041.AutoEdges := W#16#0;
   MOTOR1_No041.DataTimeCmd.StartTime := L#0;
   MOTOR1_No041.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No041.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No041.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No041.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No041.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No041.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No041.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No041.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No041.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No041.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No041.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No041.DataTimeRestart.StartTime := L#0;
   MOTOR1_No041.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No041.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No041.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No041.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No041.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No041.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No041.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No041.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No041.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No041.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No041.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No041.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No041.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No042.System := W#16#0;
   MOTOR1_No042.CmdOS := W#16#0;
   MOTOR1_No042.MirrorCmdOS := W#16#0;
   MOTOR1_No042.Test := W#16#0;
   MOTOR1_No042.AlarmOS := W#16#0;
   MOTOR1_No042.StatusOS := W#16#0;
   MOTOR1_No042.SysStatusOS := W#16#0;
   MOTOR1_No042.Status1 := W#16#0;
   MOTOR1_No042.Status2 := W#16#0;
   MOTOR1_No042.InputEdges := W#16#0;
   MOTOR1_No042.AutoEdges := W#16#0;
   MOTOR1_No042.DataTimeCmd.StartTime := L#0;
   MOTOR1_No042.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No042.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No042.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No042.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No042.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No042.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No042.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No042.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No042.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No042.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No042.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No042.DataTimeRestart.StartTime := L#0;
   MOTOR1_No042.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No042.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No042.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No042.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No042.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No042.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No042.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No042.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No042.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No042.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No042.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No042.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No042.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No043.System := W#16#0;
   MOTOR1_No043.CmdOS := W#16#0;
   MOTOR1_No043.MirrorCmdOS := W#16#0;
   MOTOR1_No043.Test := W#16#0;
   MOTOR1_No043.AlarmOS := W#16#0;
   MOTOR1_No043.StatusOS := W#16#0;
   MOTOR1_No043.SysStatusOS := W#16#0;
   MOTOR1_No043.Status1 := W#16#0;
   MOTOR1_No043.Status2 := W#16#0;
   MOTOR1_No043.InputEdges := W#16#0;
   MOTOR1_No043.AutoEdges := W#16#0;
   MOTOR1_No043.DataTimeCmd.StartTime := L#0;
   MOTOR1_No043.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No043.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No043.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No043.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No043.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No043.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No043.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No043.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No043.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No043.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No043.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No043.DataTimeRestart.StartTime := L#0;
   MOTOR1_No043.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No043.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No043.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No043.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No043.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No043.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No043.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No043.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No043.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No043.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No043.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No043.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No043.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No044.System := W#16#0;
   MOTOR1_No044.CmdOS := W#16#0;
   MOTOR1_No044.MirrorCmdOS := W#16#0;
   MOTOR1_No044.Test := W#16#0;
   MOTOR1_No044.AlarmOS := W#16#0;
   MOTOR1_No044.StatusOS := W#16#0;
   MOTOR1_No044.SysStatusOS := W#16#0;
   MOTOR1_No044.Status1 := W#16#0;
   MOTOR1_No044.Status2 := W#16#0;
   MOTOR1_No044.InputEdges := W#16#0;
   MOTOR1_No044.AutoEdges := W#16#0;
   MOTOR1_No044.DataTimeCmd.StartTime := L#0;
   MOTOR1_No044.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No044.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No044.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No044.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No044.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No044.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No044.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No044.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No044.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No044.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No044.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No044.DataTimeRestart.StartTime := L#0;
   MOTOR1_No044.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No044.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No044.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No044.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No044.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No044.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No044.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No044.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No044.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No044.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No044.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No044.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No044.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No045.System := W#16#0;
   MOTOR1_No045.CmdOS := W#16#0;
   MOTOR1_No045.MirrorCmdOS := W#16#0;
   MOTOR1_No045.Test := W#16#0;
   MOTOR1_No045.AlarmOS := W#16#0;
   MOTOR1_No045.StatusOS := W#16#0;
   MOTOR1_No045.SysStatusOS := W#16#0;
   MOTOR1_No045.Status1 := W#16#0;
   MOTOR1_No045.Status2 := W#16#0;
   MOTOR1_No045.InputEdges := W#16#0;
   MOTOR1_No045.AutoEdges := W#16#0;
   MOTOR1_No045.DataTimeCmd.StartTime := L#0;
   MOTOR1_No045.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No045.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No045.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No045.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No045.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No045.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No045.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No045.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No045.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No045.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No045.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No045.DataTimeRestart.StartTime := L#0;
   MOTOR1_No045.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No045.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No045.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No045.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No045.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No045.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No045.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No045.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No045.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No045.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No045.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No045.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No045.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No046.System := W#16#0;
   MOTOR1_No046.CmdOS := W#16#0;
   MOTOR1_No046.MirrorCmdOS := W#16#0;
   MOTOR1_No046.Test := W#16#0;
   MOTOR1_No046.AlarmOS := W#16#0;
   MOTOR1_No046.StatusOS := W#16#0;
   MOTOR1_No046.SysStatusOS := W#16#0;
   MOTOR1_No046.Status1 := W#16#0;
   MOTOR1_No046.Status2 := W#16#0;
   MOTOR1_No046.InputEdges := W#16#0;
   MOTOR1_No046.AutoEdges := W#16#0;
   MOTOR1_No046.DataTimeCmd.StartTime := L#0;
   MOTOR1_No046.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No046.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No046.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No046.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No046.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No046.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No046.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No046.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No046.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No046.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No046.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No046.DataTimeRestart.StartTime := L#0;
   MOTOR1_No046.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No046.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No046.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No046.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No046.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No046.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No046.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No046.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No046.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No046.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No046.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No046.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No046.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No047.System := W#16#0;
   MOTOR1_No047.CmdOS := W#16#0;
   MOTOR1_No047.MirrorCmdOS := W#16#0;
   MOTOR1_No047.Test := W#16#0;
   MOTOR1_No047.AlarmOS := W#16#0;
   MOTOR1_No047.StatusOS := W#16#0;
   MOTOR1_No047.SysStatusOS := W#16#0;
   MOTOR1_No047.Status1 := W#16#0;
   MOTOR1_No047.Status2 := W#16#0;
   MOTOR1_No047.InputEdges := W#16#0;
   MOTOR1_No047.AutoEdges := W#16#0;
   MOTOR1_No047.DataTimeCmd.StartTime := L#0;
   MOTOR1_No047.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No047.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No047.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No047.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No047.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No047.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No047.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No047.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No047.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No047.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No047.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No047.DataTimeRestart.StartTime := L#0;
   MOTOR1_No047.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No047.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No047.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No047.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No047.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No047.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No047.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No047.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No047.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No047.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No047.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No047.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No047.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No048.System := W#16#0;
   MOTOR1_No048.CmdOS := W#16#0;
   MOTOR1_No048.MirrorCmdOS := W#16#0;
   MOTOR1_No048.Test := W#16#0;
   MOTOR1_No048.AlarmOS := W#16#0;
   MOTOR1_No048.StatusOS := W#16#0;
   MOTOR1_No048.SysStatusOS := W#16#0;
   MOTOR1_No048.Status1 := W#16#0;
   MOTOR1_No048.Status2 := W#16#0;
   MOTOR1_No048.InputEdges := W#16#0;
   MOTOR1_No048.AutoEdges := W#16#0;
   MOTOR1_No048.DataTimeCmd.StartTime := L#0;
   MOTOR1_No048.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No048.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No048.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No048.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No048.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No048.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No048.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No048.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No048.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No048.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No048.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No048.DataTimeRestart.StartTime := L#0;
   MOTOR1_No048.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No048.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No048.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No048.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No048.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No048.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No048.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No048.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No048.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No048.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No048.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No048.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No048.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No049.System := W#16#0;
   MOTOR1_No049.CmdOS := W#16#0;
   MOTOR1_No049.MirrorCmdOS := W#16#0;
   MOTOR1_No049.Test := W#16#0;
   MOTOR1_No049.AlarmOS := W#16#0;
   MOTOR1_No049.StatusOS := W#16#0;
   MOTOR1_No049.SysStatusOS := W#16#0;
   MOTOR1_No049.Status1 := W#16#0;
   MOTOR1_No049.Status2 := W#16#0;
   MOTOR1_No049.InputEdges := W#16#0;
   MOTOR1_No049.AutoEdges := W#16#0;
   MOTOR1_No049.DataTimeCmd.StartTime := L#0;
   MOTOR1_No049.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No049.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No049.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No049.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No049.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No049.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No049.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No049.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No049.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No049.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No049.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No049.DataTimeRestart.StartTime := L#0;
   MOTOR1_No049.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No049.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No049.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No049.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No049.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No049.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No049.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No049.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No049.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No049.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No049.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No049.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No049.PCONF.DlyTStpActFault := T#0MS;
   MOTOR1_No050.System := W#16#0;
   MOTOR1_No050.CmdOS := W#16#0;
   MOTOR1_No050.MirrorCmdOS := W#16#0;
   MOTOR1_No050.Test := W#16#0;
   MOTOR1_No050.AlarmOS := W#16#0;
   MOTOR1_No050.StatusOS := W#16#0;
   MOTOR1_No050.SysStatusOS := W#16#0;
   MOTOR1_No050.Status1 := W#16#0;
   MOTOR1_No050.Status2 := W#16#0;
   MOTOR1_No050.InputEdges := W#16#0;
   MOTOR1_No050.AutoEdges := W#16#0;
   MOTOR1_No050.DataTimeCmd.StartTime := L#0;
   MOTOR1_No050.DataTimeCmd.StartEdge := FALSE;
   MOTOR1_No050.DataTimeBlackout.StartTime := L#0;
   MOTOR1_No050.DataTimeBlackout.StartEdge := FALSE;
   MOTOR1_No050.DataTimeExtFault.StartTime := L#0;
   MOTOR1_No050.DataTimeExtFault.StartEdge := FALSE;
   MOTOR1_No050.DataTimeFeedback.StartTime := L#0;
   MOTOR1_No050.DataTimeFeedback.StartEdge := FALSE;
   MOTOR1_No050.DataTimeStrtActFault.StartTime := L#0;
   MOTOR1_No050.DataTimeStrtActFault.StartEdge := FALSE;
   MOTOR1_No050.DataTimeAutoAl.StartTime := L#0;
   MOTOR1_No050.DataTimeAutoAl.StartEdge := FALSE;
   MOTOR1_No050.DataTimeRestart.StartTime := L#0;
   MOTOR1_No050.DataTimeRestart.StartEdge := FALSE;
   MOTOR1_No050.DataTimeStpActFault.StartTime := L#0;
   MOTOR1_No050.DataTimeStpActFault.StartEdge := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.DlyAFaultStop := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.sw01 := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.ExtFaultNC := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.sw03 := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.sw04 := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.sw05 := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.sw06 := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.sw07 := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.ConstOutput := TRUE;
   MOTOR1_No050.PCONF.Modeswitches.ExtraAutomode := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.NoActAFeedbackA := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.StopIfA := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.RestrtAftBlack := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.RstAStartStop := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.CmdTdly := FALSE;
   MOTOR1_No050.PCONF.Modeswitches.LockBlockCmd := FALSE;
   MOTOR1_No050.PCONF.DlyTCmd := T#0MS;
   MOTOR1_No050.PCONF.DlyTBlackout := T#0MS;
   MOTOR1_No050.PCONF.DlyTExtFault := T#0MS;
   MOTOR1_No050.PCONF.DlyTFeedback := T#0MS;
   MOTOR1_No050.PCONF.DlyTStrtActFault := T#0MS;
   MOTOR1_No050.PCONF.DlyTAutoAl := T#0MS;
   MOTOR1_No050.PCONF.DlyTRestart := T#0MS;
   MOTOR1_No050.PCONF.DlyTStpActFault := T#0MS;
END_DATA_BLOCK

